# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVE
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\EXTI;..\SYSTEM\usart;..\USER;..\STRATAGY;..\UTILITY;..\HARDWARE\STMFLASH;..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ./: test.c user.c user.h
    ../REMOTE/: link_port.c link.c link.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/: stm32f10x_gpio.c stm32f10x_rcc.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group UTILITY
    ../UTILITY/: utility.c
  group STRATAGY
    ../STRATAGY/: stratagy.c
target Target_Remote (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: TEST +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVE,MOUSE_REMOTE,EN_USART1_RX
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\EXTI;..\SYSTEM\usart;..\USER;..\STRATAGY;..\UTILITY;..\HARDWARE\STMFLASH;..\SYSTEM;..\REMOTE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
