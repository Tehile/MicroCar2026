# Keil uVision project Mouse.uvprojx, settings and files
target Mouse (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mouse +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVE
  c include: ..\APP;..\HARDWARE;..\USER;..\STRATEGY;..\MOTION
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x19400
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c STM32F10x.s
  group APP
    ../APP/: state.c menu.c calibrate.c lesson.c lesson_lab.c
  group HARDWARE
    ../HARDWARE/: delay.c sys.c usart.c core.c adc.c irs.c motor.c led.c flash.c isr.c gyro.c odom.c safety.c link.c
  group MOTION
    ../MOTION/: speedtable.c motion.c search.c spurt.c
  group STRATEGY
    ../STRATEGY/: maze.c floodfill.c path.c explore.c
software components: CMSIS:CORE 5.0.1
