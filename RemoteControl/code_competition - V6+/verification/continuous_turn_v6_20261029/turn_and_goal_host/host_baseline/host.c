
#include <string.h>
#include <stdlib.h>
#include <setjmp.h>
static jmp_buf escape;
typedef unsigned char u8;
typedef unsigned short u16;
typedef unsigned char uchar;
typedef struct {char cx,cy,action;} FASTWAYACTION;
typedef struct {char cX,cY;} MAZECOOR;
#define MAZETYPE 16
#define UP 0
#define RIGHT 1
#define DOWN 2
#define LEFT 3
#define COORADJUST
u8 actionsequence[200],action_correct_sequence[200];
u8 GucMapStep[16][16],GucMapBlock[16][16],Mapfastway_90[16][16];
FASTWAYACTION FastwayAction_90[256];
MAZECOOR GmcMouse,GmcStack[256];
u8 FastwayCount_90,GucMouseDir,sleepmode,task,goaheadbugflag;
u8 sidewall_threshold,LastSearchAction,turn_delay,keep_dis,flashwrite;
u8 lefthaswall,righthaswall,lefthaswallh,righthaswallh,forwardhaswall;
u8 lpeakfindenable,rpeakfindenable,blocknum;
u8 speedmode,ObjectGoTo_Flag,GoOrBackFlag,spurt_action_num,spurt_45_end_flag;
u16 isemergency,speed_ss,speed_turn,speed_fastss,decdistance,tick;
u16 dislpeak,disrpeak,leftpeaktrack,rightpeaktrack;
long disf,disl,disr,dislh,dislhh,disrh,disrhh;
volatile long track,absolutetrack;
long basetrack,e,eh,esum,gangle,gangleh,ganglehh,peakgangle,peakgangleh;
int turno,turnrighto,turnlefto,setvl,setvr,speed;
u8 dis2wall=40;
const u8 trackcoor=127;
char GoalX,GoalY;
double kpl,kil,kdl,kpr,kir,kdr,turn_kp,turn_kd;
float SPURT90IR_kp1,SPURT90IR_kp2,SPURT90IR_kd,SPURT90GYRO_kp,SPURT90GYRO_kd;
float SpurtAccRatio45=.7f,SpurtDecRatio45=.7f;
int LTopSpeed=140,LBottomSpeed=95;
int turn_count,stop_count,node_count,parameter_errors,fast_count,max_speed,coor_count;
int turn_codes[256],turn_at[256],fast_distance[256],fast_phase[256],node_track[256];
int sim_steps,front_plane,edge_at,edge_count,abort_at,stop_at,curve_abort;
void settrack(int t);
void sim_tick(void);
void ledoff(int n){(void)n;}
void ledon(int n){if(sleepmode==1 && n>=1 && n<=8)longjmp(escape,100+n);}
void delay_ms(int n){(void)n;}




void parameter_search(void);
void parameter_spurt(void);

u8 afterturn_flag,step,block_write_flag,lastside;
u16 disbf180,accdistance=40,stoptick,turnaround_tick;
double accratio,decratio,GOSTRAIGHT_kp=.4;
double SMARTSTRAIGHTFAST_bigerror_kp=.5,SMARTSTRAIGHTFAST_smallerror_kp=.35;
long disf1,disf2;
int speedl,speedr,setgangle;
const short *turn_gyro,*turn_vl,*turn_vr;
int pivot_at,pivot_count,departure_calls,departure_at,departure_end;
int acc_calls,acc_end,save_calls,save_at,point_calls;
int post_left,post_right,post_sample;
int coor_at[256],coor_x[256],coor_y[256],coor_dir[256];
int entry_speed[256],entry_previous[256],entry_coor_count[256];
int command_errors;
void __mouseCoorUpdate(void);
void setangle(int a){gangle=-a;}
void __wallCheck(void){
    coor_at[coor_count]=(int)absolutetrack;
    coor_x[coor_count]=GmcMouse.cX;coor_y[coor_count]=GmcMouse.cY;coor_dir[coor_count]=GucMouseDir;
    coor_count++;
}
void SaveBlockData(void){save_calls++;save_at=(int)absolutetrack;}
void exit_sensors(void){
    front_plane=0;disf=disf1=disf2=300;
    lefthaswall=lefthaswallh=post_left;righthaswall=righthaswallh=post_right;
    disl=dislh=dislhh=post_left?post_sample:200;
    disr=disrh=disrhh=post_right?post_sample:200;
    forwardhaswall=0;
}

typedef unsigned long u32;
typedef short s16;
#include <stdio.h>
#ifndef V5_SEARCH_GUARD_H
#define V5_SEARCH_GUARD_H



#define V5_FRONT_RECHECK_TASK 46
#define V5_FRONT_TRIP 10
#define V5_FRONT_CLEAR 30
#define V5_RECHECK_MIN_TICKS 50
#define V5_RECHECK_MAX_TICKS 500
#define V5_RECHECK_STABLE_SAMPLES 20
#define V5_DEADEND_CORRECTION_DIVISOR 3
#define V5_DIAG_MAGIC 0x56354431UL
#define V5_DIAG_PENDING 0
#define V5_DIAG_RECOVERED 1
#define V5_DIAG_PERSISTENT 2
#define V5_DIAG_ABORTED 3

typedef struct {
    u32 sample_seq;
    long track, absolute_track;
    long front1, front2, front_mean, left, right;
    int filtered_adc_f1, filtered_adc_f2, filtered_adc_l, filtered_adc_r;
    long target_l, target_r;
    s16 speed_l, speed_r, yaw;
    u8 task, last_action, x, y, direction, left_wall, right_wall, front_wall;
    u16 front_adc1, front_adc2;
} V5_STOP_SNAPSHOT;

typedef struct {
    u32 magic, sample_seq;
    u16 events, recovered, persistent, result;
    u8 source, active;
    u16 hold_ticks;
    u16 front_adc1, front_adc2;
    u8 deadend_limit_active, reserved;
    V5_STOP_SNAPSHOT first, last, recheck;
} V5_STOP_DIAGNOSTICS;


typedef char v5_diag_fits_reserved_ram[(sizeof(V5_STOP_DIAGNOSTICS)<=256)?1:-1];
extern volatile V5_STOP_DIAGNOSTICS v5_diag;
#endif

volatile V5_STOP_DIAGNOSTICS v5_diag;
int rawf1,rawf2,rawl,rawr;

u32 __get_PRIMASK(void){return 0;}
void __disable_irq(void){}
void __enable_irq(void){}

#define MAZESEARCH 2
#define V6_TURN_CHAIN v5_diag.reserved
u8 GucMouseTask;
int host_straight_wall;
int profile_slow[256],profile_ticks[256],profile_centre[256],profile_start[256],profile_end[256],profile_outer_peak[256];
u8 breakornot(void);
void mazesearchhaswall(void);
void mazesearchnowall(void);

void capture_profile(int i){
    int k,a,b;profile_ticks[i]=tick;profile_centre[i]=(turn_vl[1]+turn_vr[1])/2;
    profile_start[i]=turn_gyro[0];profile_end[i]=turn_gyro[tick-1];profile_outer_peak[i]=0;
    for(k=1;k<=tick;k++){a=turn_vl[k];b=turn_vr[k];if(a>profile_outer_peak[i])profile_outer_peak[i]=a;if(b>profile_outer_peak[i])profile_outer_peak[i]=b;}
}

#define Stright 0
#define TurnLeft 1
#define TurnRight 2
#define TURN180 3
#define LT90SEARCH 101	
#define	RT90SEARCH 102
#define POINTR90 103
#define POINTL90 104
#define STRAIGHT_spurt_90 105
#define LT90SPURT 106
#define	RT90SPURT 107
#define LT90L 1	  
#define	RT90L 2   
#define LV90L 3   
#define RV90L 4    
#define LT45L 5    
#define RT45L 6     
#define LV45L 7    
#define RV45L 8     
#define LT135L 9    
#define RT135L 10    
#define LV135L 11    
#define RV135L 12  
#define L180L  13    
#define R180L  14
#define STRAIGHT90L 15  
#define STRAIGHT45L 16  
#define LT90M 21	
#define	RT90M 22
#define LV90M 23
#define RV90M 24
#define LT45M 25
#define RT45M 26
#define LV45M 27
#define RV45M 28
#define LT135M 29
#define RT135M 30
#define LV135M 31
#define RV135M 32
#define L180M  33
#define R180M  34
#define STRAIGHT90M 35
#define STRAIGHT45M 36
#define LT90H 41	
#define	RT90H 42
#define LV90H 43
#define RV90H 44
#define LT45H 45
#define RT45H 46
#define LV45H 47
#define RV45H 48
#define LT135H 49
#define RT135H 50
#define LV135H 51
#define RV135H 52
#define L180H  53
#define R180H  54
#define STRAIGHT90H 55
#define STRAIGHT45H 56
#define LOW_90 60
#define LOW 61
#define MEDIUM 62
#define HIGH 63
#define BOTHSIDE 80
#define LEFTSIDE 81
#define RIGHTSIDE 82
#define NOSIDE		83
#define MAXPWM	1500
#define ACCV0 10
#define SPEED_HAHA 350
#define NULL 0
#define GOSTRAIGHT 1
#define TURN 2
#define TURNAROUND 4
#define STOP 5
#define SUPERSTRAIGHT 12
#define INFRSTRAIGHT 13
#define TURNLEFTFAST 14
#define TURNRIGHTFAST 15
#define EMERGENCY 16
#define STRAIGHT45 17
#define FASTSTRAIGHT 18
#define BEFORE90TURN 27
#define BEFORE180TURN 28
#define AFTER180TURN 29
#define SMARTSTRAIGHT 30
#define CHANGESPEED 31
#define SMARTSTRAIGHTFAST 32  
#define STRAIGHTEYECLOSECOORADJ 33
#define STRAIGHTPOLE 34
#define ACC 35
#define SLOWDOWN 36
#define SPEEDUP 37
#define KEEPWALLDISTANCE 38
#define POINTTURN90 39
#define EDGESTRAIGHT 40
#define FORWARDIRTEST 41
#define SPURT90BLIND 42
#define SPURT90IR 43
#define SMARTSTRAIGHTSPURT 44
#define SMARTSTRAIGHTSPURTL 45
#ifndef GOAL_DEPARTURE_EXTRA_MM
#define GOAL_DEPARTURE_EXTRA_MM 0
#endif
#if GOAL_DEPARTURE_EXTRA_MM != 0 && GOAL_DEPARTURE_EXTRA_MM != 2 && GOAL_DEPARTURE_EXTRA_MM != 4 && GOAL_DEPARTURE_EXTRA_MM != 6
#error GOAL_DEPARTURE_EXTRA_MM_must_be_0_2_4_or_6
#endif


#define spurt_plan_start_dir action_correct_sequence[196]
#define spurt_exec_index     action_correct_sequence[197]
#define spurt_search_active  action_correct_sequence[198]
#define spurt_search_failed  action_correct_sequence[199]
static u8 spurtSearchRunning(void);

const short vouter_spurt[1]={0};
const short vinner_spurt[1]={0};
const short gyro_l_spurt[1]={0};
const short gyro_r_spurt[1]={0};
const short gyro_l_search[195]={90, 90, 89, 89, 88, 88, 87, 87, 86, 86, 85, 85, 84, 84, 83, 83, 82, 82, 81, 81, 80, 80, 79, 79, 79, 78, 78, 77, 77, 76, 76, 75, 75, 74, 74, 73, 73, 72, 72, 71, 71, 70, 70, 69, 69, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 64, 63, 63, 62, 62, 61, 61, 60, 60, 59, 59, 58, 58, 58, 57, 57, 56, 56, 55, 55, 54, 54, 53, 53, 52, 52, 51, 51, 50, 50, 49, 49, 48, 48, 48, 47, 47, 46, 46, 45, 45, 44, 44, 43, 43, 42, 42, 41, 41, 40, 40, 39, 39, 38, 38, 37, 37, 37, 36, 36, 35, 35, 34, 34, 33, 33, 32, 32, 31, 31, 30, 30, 29, 29, 28, 28, 27, 27, 26, 26, 26, 25, 25, 24, 24, 23, 23, 22, 22, 21, 21, 20, 20, 19, 19, 18, 18, 17, 17, 16, 16, 16, 15, 15, 14, 14, 13, 13, 12, 12, 11, 11, 10, 10, 9, 9, 8, 8, 7, 7, 6, 6, 5, 5, 5, 4, 4, 3, 3, 2, 2, 1, 1, 0, 0, -1, -1, -2, -2, -3};
const short gyro_r_search[195]={-90, -90, -89, -89, -88, -88, -87, -87, -86, -86, -85, -85, -84, -84, -83, -83, -82, -82, -81, -81, -80, -80, -79, -79, -79, -78, -78, -77, -77, -76, -76, -75, -75, -74, -74, -73, -73, -72, -72, -71, -71, -70, -70, -69, -69, -69, -68, -68, -67, -67, -66, -66, -65, -65, -64, -64, -63, -63, -62, -62, -61, -61, -60, -60, -59, -59, -58, -58, -58, -57, -57, -56, -56, -55, -55, -54, -54, -53, -53, -52, -52, -51, -51, -50, -50, -49, -49, -48, -48, -48, -47, -47, -46, -46, -45, -45, -44, -44, -43, -43, -42, -42, -41, -41, -40, -40, -39, -39, -38, -38, -37, -37, -37, -36, -36, -35, -35, -34, -34, -33, -33, -32, -32, -31, -31, -30, -30, -29, -29, -28, -28, -27, -27, -26, -26, -26, -25, -25, -24, -24, -23, -23, -22, -22, -21, -21, -20, -20, -19, -19, -18, -18, -17, -17, -16, -16, -16, -15, -15, -14, -14, -13, -13, -12, -12, -11, -11, -10, -10, -9, -9, -8, -8, -7, -7, -6, -6, -5, -5, -5, -4, -4, -3, -3, -2, -2, -1, -1, 0, 0, 1, 1, 2, 2, 3};
const short vouter_search[195]={70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 107, 108, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 108, 107, 106, 105, 104, 103, 102, 101, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 90, 89, 88, 87, 86, 85, 84, 83, 82, 81, 80, 79, 78, 77, 76, 75, 74, 73, 72, 71, 70};
const short vinner_search[195]={70, 69, 68, 67, 66, 65, 64, 63, 62, 61, 60, 59, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 48, 47, 46, 45, 44, 43, 42, 41, 40, 39, 38, 37, 36, 35, 34, 33, 32, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70};
const short vouter_t90_low[195]={70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 107, 108, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 108, 107, 106, 105, 104, 103, 102, 101, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 90, 89, 88, 87, 86, 85, 84, 83, 82, 81, 80, 79, 78, 77, 76, 75, 74, 73, 72, 71, 70};
const short vinner_t90_low[195]={70, 69, 68, 67, 66, 65, 64, 63, 62, 61, 60, 59, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 48, 47, 46, 45, 44, 43, 42, 41, 40, 39, 38, 37, 36, 35, 34, 33, 32, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70};
const short gyro_lt90_low[195]={90, 90, 89, 89, 88, 88, 87, 87, 86, 86, 85, 85, 84, 84, 83, 83, 82, 82, 81, 81, 80, 80, 79, 79, 79, 78, 78, 77, 77, 76, 76, 75, 75, 74, 74, 73, 73, 72, 72, 71, 71, 70, 70, 69, 69, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 64, 63, 63, 62, 62, 61, 61, 60, 60, 59, 59, 58, 58, 58, 57, 57, 56, 56, 55, 55, 54, 54, 53, 53, 52, 52, 51, 51, 50, 50, 49, 49, 48, 48, 48, 47, 47, 46, 46, 45, 45, 44, 44, 43, 43, 42, 42, 41, 41, 40, 40, 39, 39, 38, 38, 37, 37, 37, 36, 36, 35, 35, 34, 34, 33, 33, 32, 32, 31, 31, 30, 30, 29, 29, 28, 28, 27, 27, 26, 26, 26, 25, 25, 24, 24, 23, 23, 22, 22, 21, 21, 20, 20, 19, 19, 18, 18, 17, 17, 16, 16, 16, 15, 15, 14, 14, 13, 13, 12, 12, 11, 11, 10, 10, 9, 9, 8, 8, 7, 7, 6, 6, 5, 5, 5, 4, 4, 3, 3, 2, 2, 1, 1, 0, 0, -1, -1, -2, -2, -3};
const short gyro_rt90_low[195]={-90, -90, -89, -89, -88, -88, -87, -87, -86, -86, -85, -85, -84, -84, -83, -83, -82, -82, -81, -81, -80, -80, -79, -79, -79, -78, -78, -77, -77, -76, -76, -75, -75, -74, -74, -73, -73, -72, -72, -71, -71, -70, -70, -69, -69, -69, -68, -68, -67, -67, -66, -66, -65, -65, -64, -64, -63, -63, -62, -62, -61, -61, -60, -60, -59, -59, -58, -58, -58, -57, -57, -56, -56, -55, -55, -54, -54, -53, -53, -52, -52, -51, -51, -50, -50, -49, -49, -48, -48, -48, -47, -47, -46, -46, -45, -45, -44, -44, -43, -43, -42, -42, -41, -41, -40, -40, -39, -39, -38, -38, -37, -37, -37, -36, -36, -35, -35, -34, -34, -33, -33, -32, -32, -31, -31, -30, -30, -29, -29, -28, -28, -27, -27, -26, -26, -26, -25, -25, -24, -24, -23, -23, -22, -22, -21, -21, -20, -20, -19, -19, -18, -18, -17, -17, -16, -16, -16, -15, -15, -14, -14, -13, -13, -12, -12, -11, -11, -10, -10, -9, -9, -8, -8, -7, -7, -6, -6, -5, -5, -5, -4, -4, -3, -3, -2, -2, -1, -1, 0, 0, 1, 1, 2, 2, 3};
const short gyro_lv90_low[187]={90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,89,89,89,89,89,89,89,88,88,88,88,88,87,87,87,87,86,86,86,85,85,85,84,84,84,83,83,83,82,82,81,81,81,80,80,79,79,78,78,77,77,76,75,75,74,74,73,73,72,71,71,70,69,69,68,67,67,66,65,64,64,63,62,61,61,60,59,58,57,56,56,55,54,53,52,51,50,49,48,47,46,46,45,44,43,42,41,40,39,38,37,36,35,34,33,32,32,31,30,29,28,27,26,25,24,23,22,21,20,19,19,18,17,16,15,14,14,13,12,11,10,10,9,8,7,7,6,5,5,4,4,3,3,2,2,2,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rv90_low[187]={-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-89,-89,-89,-89,-89,-89,-89,-88,-88,-88,-88,-88,-87,-87,-87,-87,-86,-86,-86,-85,-85,-85,-84,-84,-84,-83,-83,-83,-82,-82,-81,-81,-81,-80,-80,-79,-79,-78,-78,-77,-77,-76,-75,-75,-74,-74,-73,-73,-72,-71,-71,-70,-69,-69,-68,-67,-67,-66,-65,-64,-64,-63,-62,-61,-61,-60,-59,-58,-57,-56,-56,-55,-54,-53,-52,-51,-50,-49,-48,-47,-46,-46,-45,-44,-43,-42,-41,-40,-39,-38,-37,-36,-35,-34,-33,-32,-32,-31,-30,-29,-28,-27,-26,-25,-24,-23,-22,-21,-20,-19,-19,-18,-17,-16,-15,-14,-14,-13,-12,-11,-10,-10,-9,-8,-7,-7,-6,-5,-5,-4,-4,-3,-3,-2,-2,-2,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_v90_low[187]={100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,100,100,100,101,101,102,102,103,103,104,104,105,105,106,106,107,107,108,108,109,109,110,110,111,111,112,112,113,113,114,115,116,116,117,118,119,120,121,121,122,123,124,125,126,126,127,128,129,130,131,131,132,133,134,135,136,136,137,137,138,138,138,139,139,139,139,140,140,140,141,141,141,142,142,142,142,143,143,143,144,144,144,144,145,145,145,145,145,145,144,144,143,143,142,142,141,141,141,140,140,139,139,138,138,137,137,135,133,131,129,127,126,124,122,120,118,116,114,112,110,108,106,104,102,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_v90_low[187]={100,99,97,96,95,93,92,91,89,88,87,85,84,82,81,80,78,77,76,74,73,72,70,69,68,66,65,64,62,61,60,59,58,58,57,56,55,54,53,53,52,51,50,49,48,48,47,46,45,44,44,43,42,41,40,39,39,38,37,36,36,35,35,34,34,34,33,33,32,32,31,31,30,30,29,29,28,28,27,27,26,26,25,25,24,24,23,23,23,24,24,24,25,25,25,25,26,26,26,27,27,27,27,28,28,28,29,29,29,30,30,30,30,31,31,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,52,54,57,59,62,64,67,69,72,74,77,79,82,84,87,89,92,94,97,99,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short gyro_lt45_low[152]={45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,44,44,44,44,43,43,43,42,42,41,41,41,40,39,39,38,38,37,36,36,35,34,34,33,32,32,31,30,29,29,28,27,27,26,25,25,24,23,23,22,21,21,20,19,19,18,17,17,16,16,15,15,14,14,13,13,12,12,11,11,10,10,9,9,8,8,8,7,7,6,6,6,5,5,5,4,4,4,4,3,3,3,3,2,2,2,2,2,1,1,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rt45_low[152]={-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-44,-44,-44,-44,-43,-43,-43,-42,-42,-41,-41,-41,-40,-39,-39,-38,-38,-37,-36,-36,-35,-34,-34,-33,-32,-32,-31,-30,-29,-29,-28,-27,-27,-26,-25,-25,-24,-23,-23,-22,-21,-21,-20,-19,-19,-18,-17,-17,-16,-16,-15,-15,-14,-14,-13,-13,-12,-12,-11,-11,-10,-10,-9,-9,-8,-8,-8,-7,-7,-6,-6,-6,-5,-5,-5,-4,-4,-4,-4,-3,-3,-3,-3,-2,-2,-2,-2,-2,-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_t45_low[152]={100,100,100,101,101,101,101,102,102,102,102,103,103,104,105,107,108,109,111,112,114,115,117,118,119,121,121,121,121,121,121,122,122,122,122,122,122,122,122,123,123,123,123,123,123,122,122,121,121,120,120,119,119,118,118,117,117,116,115,115,114,114,113,113,112,112,112,112,111,111,111,111,110,110,110,110,109,109,109,109,108,108,108,107,107,107,107,106,106,106,106,105,105,105,105,104,104,104,104,103,103,103,103,102,102,102,101,101,101,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_t45_low[152]={100,97,93,90,86,83,79,76,72,69,66,62,59,56,54,51,49,47,45,42,40,38,36,34,31,29,29,30,30,30,30,30,30,30,30,31,31,31,31,31,31,31,31,32,32,33,34,34,35,36,37,38,38,39,40,41,42,42,43,44,45,46,46,47,48,49,50,52,53,54,55,56,57,58,59,60,61,62,63,65,66,67,68,69,70,71,72,73,74,75,76,78,79,80,81,82,83,84,85,86,87,88,89,91,92,93,94,95,96,97,98,99,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short gyro_lv45_low[171]={45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,44,44,44,44,44,44,43,43,43,43,42,42,42,42,41,41,41,40,40,39,39,39,38,38,37,37,36,36,35,35,34,33,33,32,32,31,30,30,29,28,27,27,26,25,24,24,23,22,21,20,19,18,18,17,16,15,14,13,12,11,11,10,9,8,7,6,5,5,4,3,3,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rv45_low[171]={-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-44,-44,-44,-44,-44,-44,-43,-43,-43,-43,-42,-42,-42,-42,-41,-41,-41,-40,-40,-39,-39,-39,-38,-38,-37,-37,-36,-36,-35,-35,-34,-33,-33,-32,-32,-31,-30,-30,-29,-28,-27,-27,-26,-25,-24,-24,-23,-22,-21,-20,-19,-18,-18,-17,-16,-15,-14,-13,-12,-11,-11,-10,-9,-8,-7,-6,-5,-5,-4,-3,-3,-2,-2,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_v45_low[171]={100,100,100,99,99,99,99,99,99,98,98,98,98,98,97,97,97,97,97,97,96,96,96,96,96,95,95,95,95,95,95,94,94,94,94,94,94,93,93,93,93,93,92,92,92,92,92,92,91,91,91,91,91,91,91,92,93,94,94,95,96,97,98,98,99,100,101,101,102,103,104,105,105,106,107,108,108,109,110,111,111,112,113,114,115,115,116,117,118,118,119,120,121,121,122,123,124,125,125,126,127,128,128,129,130,131,132,132,133,134,135,135,136,136,136,137,137,137,138,138,138,139,139,139,140,140,139,136,134,131,128,126,123,120,117,115,112,109,107,104,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_v45_low[171]={100,100,100,99,99,99,99,99,99,98,98,98,98,98,97,97,97,97,97,97,96,96,96,96,96,95,95,95,95,95,95,94,94,94,94,94,94,93,93,93,93,93,92,92,92,92,92,92,91,91,91,91,91,90,89,88,87,86,85,83,82,81,80,79,78,77,76,74,73,72,71,70,69,68,66,65,64,63,62,61,60,59,57,56,55,54,53,52,51,49,48,47,46,45,44,43,42,40,39,38,37,36,35,34,33,31,30,29,28,27,26,25,25,25,26,26,27,27,27,28,28,28,29,29,29,30,32,37,41,46,51,55,60,65,70,74,79,84,88,93,98,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short gyro_lt135_low[302]={135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,134,134,134,134,134,134,134,134,134,134,133,133,133,133,133,133,132,132,132,132,132,131,131,131,131,131,130,130,130,130,129,129,129,128,128,128,128,127,127,127,126,126,126,125,125,125,124,124,124,123,123,122,122,122,121,121,120,120,119,119,119,118,118,117,117,116,116,115,115,114,114,113,113,112,112,111,111,110,109,109,108,108,107,107,106,105,105,104,104,103,102,102,101,100,100,99,98,98,97,96,96,95,94,94,93,92,91,91,90,89,88,88,87,86,85,85,84,83,82,81,81,80,79,78,77,76,75,75,74,73,72,71,70,69,69,68,67,66,65,64,63,63,62,61,60,59,58,57,56,56,55,54,53,52,51,50,50,49,48,47,46,45,44,43,43,42,41,40,39,38,37,37,36,35,34,33,32,31,31,30,29,28,27,26,26,25,24,23,22,22,21,20,19,19,18,17,17,16,15,14,14,13,12,12,11,10,10,9,9,8,7,7,6,6,5,5,4,4,4,3,3,3,2,2,2,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rt135_low[302]={-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-134,-134,-134,-134,-134,-134,-134,-134,-134,-134,-133,-133,-133,-133,-133,-133,-132,-132,-132,-132,-132,-131,-131,-131,-131,-131,-130,-130,-130,-130,-129,-129,-129,-128,-128,-128,-128,-127,-127,-127,-126,-126,-126,-125,-125,-125,-124,-124,-124,-123,-123,-122,-122,-122,-121,-121,-120,-120,-119,-119,-119,-118,-118,-117,-117,-116,-116,-115,-115,-114,-114,-113,-113,-112,-112,-111,-111,-110,-109,-109,-108,-108,-107,-107,-106,-105,-105,-104,-104,-103,-102,-102,-101,-100,-100,-99,-98,-98,-97,-96,-96,-95,-94,-94,-93,-92,-91,-91,-90,-89,-88,-88,-87,-86,-85,-85,-84,-83,-82,-81,-81,-80,-79,-78,-77,-76,-75,-75,-74,-73,-72,-71,-70,-69,-69,-68,-67,-66,-65,-64,-63,-63,-62,-61,-60,-59,-58,-57,-56,-56,-55,-54,-53,-52,-51,-50,-50,-49,-48,-47,-46,-45,-44,-43,-43,-42,-41,-40,-39,-38,-37,-37,-36,-35,-34,-33,-32,-31,-31,-30,-29,-28,-27,-26,-26,-25,-24,-23,-22,-22,-21,-20,-19,-19,-18,-17,-17,-16,-15,-14,-14,-13,-12,-12,-11,-10,-10,-9,-9,-8,-7,-7,-6,-6,-5,-5,-4,-4,-4,-3,-3,-3,-2,-2,-2,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_t135_low[302]={100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,100,100,100,100,101,101,101,102,102,102,103,103,103,103,104,104,104,105,105,105,106,106,106,106,107,107,107,108,108,108,108,109,109,109,110,110,110,111,111,111,111,112,112,112,113,113,113,114,114,115,115,116,116,117,117,118,118,119,119,120,120,121,121,122,122,123,123,124,124,125,125,126,126,127,127,128,129,129,130,130,131,131,132,132,133,133,134,134,135,135,136,136,136,136,137,137,137,137,137,137,138,138,138,138,138,139,139,139,139,139,139,140,140,140,140,140,141,141,141,141,141,141,142,142,142,142,142,143,143,143,143,143,143,144,144,144,144,144,144,144,144,143,143,143,143,142,142,142,142,141,141,141,141,140,140,140,139,139,139,139,138,138,138,138,137,137,137,137,136,136,134,133,132,131,130,129,127,126,125,124,123,122,120,119,118,117,116,115,114,112,111,110,109,108,107,105,104,103,102,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_t135_low[302]={100,99,98,98,97,96,95,94,93,93,92,91,90,89,88,88,87,86,85,84,83,83,82,81,80,79,79,78,77,76,75,74,74,73,72,71,70,69,69,68,67,66,65,65,64,63,62,61,61,60,60,59,59,58,58,57,57,56,56,55,55,54,54,53,53,52,52,51,51,50,50,49,49,48,48,47,47,46,46,45,45,44,44,43,43,42,42,41,41,40,40,39,39,38,38,37,37,37,36,36,36,35,35,35,35,34,34,34,33,33,33,33,32,32,32,31,31,31,31,30,30,30,29,29,29,29,28,28,28,27,27,27,27,26,26,26,25,25,25,25,24,24,24,25,25,25,25,25,26,26,26,26,26,26,27,27,27,27,27,28,28,28,28,28,28,29,29,29,29,29,30,30,30,30,30,30,31,31,31,31,31,32,32,32,32,32,32,33,33,34,34,35,36,36,37,38,38,39,39,40,41,41,42,43,43,44,45,45,46,46,47,48,48,49,50,50,51,51,52,53,55,56,58,59,61,62,64,65,67,68,70,72,73,75,76,78,79,81,82,84,85,87,88,90,91,93,94,96,97,99,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short gyro_lv135_low[294]={135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,134,134,134,134,134,134,134,134,134,134,134,133,133,133,133,133,133,133,132,132,132,132,132,131,131,131,131,131,130,130,130,130,130,129,129,129,129,128,128,128,128,127,127,127,126,126,126,125,125,125,124,124,124,123,123,123,122,122,122,121,121,121,120,120,119,119,119,118,118,117,117,116,116,116,115,115,114,114,113,113,112,112,111,111,110,110,109,109,108,108,107,107,106,106,105,104,104,103,103,102,102,101,100,100,99,99,98,97,97,96,96,95,94,94,93,92,92,91,90,90,89,88,87,87,86,85,85,84,83,82,82,81,80,79,79,78,77,76,76,75,74,73,73,72,71,70,69,69,68,67,66,65,65,64,63,62,61,61,60,59,58,57,57,56,55,54,54,53,52,51,50,50,49,48,47,46,46,45,44,43,42,42,41,40,39,39,38,37,36,35,35,34,33,32,31,31,30,29,28,28,27,26,25,25,24,23,23,22,21,20,20,19,18,18,17,16,16,15,15,14,13,13,12,11,11,10,10,9,9,8,7,7,7,6,6,5,5,4,4,4,3,3,3,2,2,2,2,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rv135_low[294]={-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-134,-134,-134,-134,-134,-134,-134,-134,-134,-134,-134,-133,-133,-133,-133,-133,-133,-133,-132,-132,-132,-132,-132,-131,-131,-131,-131,-131,-130,-130,-130,-130,-130,-129,-129,-129,-129,-128,-128,-128,-128,-127,-127,-127,-126,-126,-126,-125,-125,-125,-124,-124,-124,-123,-123,-123,-122,-122,-122,-121,-121,-121,-120,-120,-119,-119,-119,-118,-118,-117,-117,-116,-116,-116,-115,-115,-114,-114,-113,-113,-112,-112,-111,-111,-110,-110,-109,-109,-108,-108,-107,-107,-106,-106,-105,-104,-104,-103,-103,-102,-102,-101,-100,-100,-99,-99,-98,-97,-97,-96,-96,-95,-94,-94,-93,-92,-92,-91,-90,-90,-89,-88,-87,-87,-86,-85,-85,-84,-83,-82,-82,-81,-80,-79,-79,-78,-77,-76,-76,-75,-74,-73,-73,-72,-71,-70,-69,-69,-68,-67,-66,-65,-65,-64,-63,-62,-61,-61,-60,-59,-58,-57,-57,-56,-55,-54,-54,-53,-52,-51,-50,-50,-49,-48,-47,-46,-46,-45,-44,-43,-42,-42,-41,-40,-39,-39,-38,-37,-36,-35,-35,-34,-33,-32,-31,-31,-30,-29,-28,-28,-27,-26,-25,-25,-24,-23,-23,-22,-21,-20,-20,-19,-18,-18,-17,-16,-16,-15,-15,-14,-13,-13,-12,-11,-11,-10,-10,-9,-9,-8,-7,-7,-7,-6,-6,-5,-5,-4,-4,-4,-3,-3,-3,-2,-2,-2,-2,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_v135_low[294]={100,100,100,100,100,100,100,100,100,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,97,97,97,97,97,97,97,97,97,97,97,98,98,98,98,99,99,99,99,100,100,100,100,100,101,101,101,101,102,102,102,102,103,103,103,103,104,104,104,104,104,105,105,105,105,106,106,106,106,107,107,107,107,107,108,108,108,108,109,109,109,110,110,111,111,111,112,112,113,113,114,114,114,115,115,116,116,117,117,117,118,118,119,119,120,120,120,121,121,122,122,123,123,123,124,124,125,125,126,126,126,127,127,128,128,129,129,129,130,130,131,131,131,131,132,132,132,132,132,132,133,133,133,133,133,133,134,134,134,134,134,134,135,135,135,135,135,135,136,136,136,136,136,136,137,137,137,137,137,137,138,138,138,138,138,138,139,139,139,139,139,139,140,139,139,139,139,139,138,138,138,138,138,137,137,137,137,137,136,136,136,136,135,135,135,135,135,134,134,134,134,134,133,133,133,133,133,132,131,130,129,128,127,126,125,124,123,122,121,120,119,118,118,117,116,115,114,113,112,111,110,109,108,107,106,105,104,103,102,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_v135_low[294]={100,99,99,98,97,96,96,95,94,94,93,92,91,91,90,89,88,88,87,86,86,85,84,83,83,82,81,81,80,79,78,78,77,76,75,75,74,73,73,72,71,70,70,69,68,68,67,66,65,65,64,63,63,62,62,61,61,61,60,60,59,59,58,58,58,57,57,56,56,55,55,55,54,54,53,53,52,52,52,51,51,50,50,49,49,49,48,48,47,47,46,46,46,45,45,44,44,43,43,42,42,42,41,41,41,40,40,40,40,39,39,39,39,39,38,38,38,38,37,37,37,37,36,36,36,36,35,35,35,35,35,34,34,34,34,33,33,33,33,32,32,32,32,32,31,31,31,31,30,30,30,30,29,29,29,29,29,30,30,30,30,30,30,31,31,31,31,31,31,32,32,32,32,32,32,33,33,33,33,33,33,34,34,34,34,34,34,35,35,35,35,35,35,36,36,36,36,36,36,37,37,37,37,37,37,38,38,39,39,40,40,41,41,42,42,43,43,44,45,45,46,46,47,47,48,48,49,49,50,50,51,52,52,53,53,54,54,55,55,56,57,58,60,61,62,63,65,66,67,69,70,71,72,74,75,76,78,79,80,81,83,84,85,87,88,89,90,92,93,94,96,97,98,99,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vouter_180_low[391]={70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 101, 102, 103, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 103, 102, 101, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 90, 89, 88, 87, 86, 85, 84, 83, 82, 81, 80, 79, 78, 77, 76, 75, 74, 73, 72, 71, 70};
const short vinner_180_low[391]={70, 69, 68, 67, 66, 65, 64, 63, 62, 61, 60, 59, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 48, 47, 46, 45, 44, 43, 42, 41, 40, 39, 38, 37, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70};
const short gyro_l180_low[391]={180, 180, 179, 179, 178, 178, 177, 177, 176, 176, 175, 175, 174, 174, 173, 173, 172, 172, 171, 171, 170, 170, 169, 169, 169, 168, 168, 167, 167, 166, 166, 165, 165, 164, 164, 163, 163, 162, 162, 161, 161, 160, 160, 159, 159, 159, 158, 158, 157, 157, 156, 156, 155, 155, 154, 154, 153, 153, 152, 152, 151, 151, 150, 150, 149, 149, 148, 148, 148, 147, 147, 146, 146, 145, 145, 144, 144, 143, 143, 142, 142, 141, 141, 140, 140, 139, 139, 138, 138, 138, 137, 137, 136, 136, 135, 135, 134, 134, 133, 133, 132, 132, 131, 131, 130, 130, 129, 129, 128, 128, 127, 127, 127, 126, 126, 125, 125, 124, 124, 123, 123, 122, 122, 121, 121, 120, 120, 119, 119, 118, 118, 117, 117, 116, 116, 116, 115, 115, 114, 114, 113, 113, 112, 112, 111, 111, 110, 110, 109, 109, 108, 108, 107, 107, 106, 106, 106, 105, 105, 104, 104, 103, 103, 102, 102, 101, 101, 100, 100, 99, 99, 98, 98, 97, 97, 96, 96, 95, 95, 95, 94, 94, 93, 93, 92, 92, 91, 91, 90, 90, 89, 89, 88, 88, 87, 87, 86, 86, 85, 85, 85, 84, 84, 83, 83, 82, 82, 81, 81, 80, 80, 79, 79, 78, 78, 77, 77, 76, 76, 75, 75, 74, 74, 74, 73, 73, 72, 72, 71, 71, 70, 70, 69, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 64, 63, 63, 63, 62, 62, 61, 61, 60, 60, 59, 59, 58, 58, 57, 57, 56, 56, 55, 55, 54, 54, 53, 53, 53, 52, 52, 51, 51, 50, 50, 49, 49, 48, 48, 47, 47, 46, 46, 45, 45, 44, 44, 43, 43, 42, 42, 42, 41, 41, 40, 40, 39, 39, 38, 38, 37, 37, 36, 36, 35, 35, 34, 34, 33, 33, 32, 32, 32, 31, 31, 30, 30, 29, 29, 28, 28, 27, 27, 26, 26, 25, 25, 24, 24, 23, 23, 22, 22, 21, 21, 21, 20, 20, 19, 19, 18, 18, 17, 17, 16, 16, 15, 15, 14, 14, 13, 13, 12, 12, 11, 11, 10, 10, 10, 9, 9, 8, 8, 7, 7, 6, 6, 5, 5, 4, 4, 3, 3, 2, 2, 1, 1, 0, 0, 0, -1, -1, -2, -2, -3, -3, -4, -4, -5, -5, -6, -6};
const short gyro_r180_low[391]={-180, -180, -179, -179, -178, -178, -177, -177, -176, -176, -175, -175, -174, -174, -173, -173, -172, -172, -171, -171, -170, -170, -169, -169, -169, -168, -168, -167, -167, -166, -166, -165, -165, -164, -164, -163, -163, -162, -162, -161, -161, -160, -160, -159, -159, -159, -158, -158, -157, -157, -156, -156, -155, -155, -154, -154, -153, -153, -152, -152, -151, -151, -150, -150, -149, -149, -148, -148, -148, -147, -147, -146, -146, -145, -145, -144, -144, -143, -143, -142, -142, -141, -141, -140, -140, -139, -139, -138, -138, -138, -137, -137, -136, -136, -135, -135, -134, -134, -133, -133, -132, -132, -131, -131, -130, -130, -129, -129, -128, -128, -127, -127, -127, -126, -126, -125, -125, -124, -124, -123, -123, -122, -122, -121, -121, -120, -120, -119, -119, -118, -118, -117, -117, -116, -116, -116, -115, -115, -114, -114, -113, -113, -112, -112, -111, -111, -110, -110, -109, -109, -108, -108, -107, -107, -106, -106, -106, -105, -105, -104, -104, -103, -103, -102, -102, -101, -101, -100, -100, -99, -99, -98, -98, -97, -97, -96, -96, -95, -95, -95, -94, -94, -93, -93, -92, -92, -91, -91, -90, -90, -89, -89, -88, -88, -87, -87, -86, -86, -85, -85, -85, -84, -84, -83, -83, -82, -82, -81, -81, -80, -80, -79, -79, -78, -78, -77, -77, -76, -76, -75, -75, -74, -74, -74, -73, -73, -72, -72, -71, -71, -70, -70, -69, -69, -68, -68, -67, -67, -66, -66, -65, -65, -64, -64, -63, -63, -63, -62, -62, -61, -61, -60, -60, -59, -59, -58, -58, -57, -57, -56, -56, -55, -55, -54, -54, -53, -53, -53, -52, -52, -51, -51, -50, -50, -49, -49, -48, -48, -47, -47, -46, -46, -45, -45, -44, -44, -43, -43, -42, -42, -42, -41, -41, -40, -40, -39, -39, -38, -38, -37, -37, -36, -36, -35, -35, -34, -34, -33, -33, -32, -32, -32, -31, -31, -30, -30, -29, -29, -28, -28, -27, -27, -26, -26, -25, -25, -24, -24, -23, -23, -22, -22, -21, -21, -21, -20, -20, -19, -19, -18, -18, -17, -17, -16, -16, -15, -15, -14, -14, -13, -13, -12, -12, -11, -11, -10, -10, -10, -9, -9, -8, -8, -7, -7, -6, -6, -5, -5, -4, -4, -3, -3, -2, -2, -1, -1, 0, 0, 0, 1, 1, 2, 2, 3, 3, 4, 4, 5, 5, 6, 6};
const short vl_around[628]={0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 20, 19, 18, 17, 16, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 5, 4, 3, 2, 1, 0};
const short vr_around[628]={0, -1, -2, -3, -4, -5, -6, -7, -8, -9, -10, -11, -12, -13, -14, -15, -16, -17, -18, -19, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10, -9, -8, -7, -6, -5, -4, -3, -2, -1, 0};
const short gyro_around[628]={-180, -180, -180, -180, -180, -180, -180, -180, -180, -179, -179, -179, -179, -179, -179, -178, -178, -178, -178, -177, -177, -177, -176, -176, -176, -176, -175, -175, -175, -174, -174, -174, -173, -173, -173, -173, -172, -172, -172, -171, -171, -171, -171, -170, -170, -170, -169, -169, -169, -168, -168, -168, -168, -167, -167, -167, -166, -166, -166, -165, -165, -165, -165, -164, -164, -164, -163, -163, -163, -162, -162, -162, -162, -161, -161, -161, -160, -160, -160, -160, -159, -159, -159, -158, -158, -158, -157, -157, -157, -157, -156, -156, -156, -155, -155, -155, -154, -154, -154, -154, -153, -153, -153, -152, -152, -152, -152, -151, -151, -151, -150, -150, -150, -149, -149, -149, -149, -148, -148, -148, -147, -147, -147, -146, -146, -146, -146, -145, -145, -145, -144, -144, -144, -143, -143, -143, -143, -142, -142, -142, -141, -141, -141, -141, -140, -140, -140, -139, -139, -139, -138, -138, -138, -138, -137, -137, -137, -136, -136, -136, -135, -135, -135, -135, -134, -134, -134, -133, -133, -133, -133, -132, -132, -132, -131, -131, -131, -130, -130, -130, -130, -129, -129, -129, -128, -128, -128, -127, -127, -127, -127, -126, -126, -126, -125, -125, -125, -124, -124, -124, -124, -123, -123, -123, -122, -122, -122, -122, -121, -121, -121, -120, -120, -120, -119, -119, -119, -119, -118, -118, -118, -117, -117, -117, -116, -116, -116, -116, -115, -115, -115, -114, -114, -114, -114, -113, -113, -113, -112, -112, -112, -111, -111, -111, -111, -110, -110, -110, -109, -109, -109, -108, -108, -108, -108, -107, -107, -107, -106, -106, -106, -105, -105, -105, -105, -104, -104, -104, -103, -103, -103, -103, -102, -102, -102, -101, -101, -101, -100, -100, -100, -100, -99, -99, -99, -98, -98, -98, -97, -97, -97, -97, -96, -96, -96, -95, -95, -95, -95, -94, -94, -94, -93, -93, -93, -92, -92, -92, -92, -91, -91, -91, -90, -90, -90, -89, -89, -89, -89, -88, -88, -88, -87, -87, -87, -86, -86, -86, -86, -85, -85, -85, -84, -84, -84, -84, -83, -83, -83, -82, -82, -82, -81, -81, -81, -81, -80, -80, -80, -79, -79, -79, -78, -78, -78, -78, -77, -77, -77, -76, -76, -76, -76, -75, -75, -75, -74, -74, -74, -73, -73, -73, -73, -72, -72, -72, -71, -71, -71, -70, -70, -70, -70, -69, -69, -69, -68, -68, -68, -67, -67, -67, -67, -66, -66, -66, -65, -65, -65, -65, -64, -64, -64, -63, -63, -63, -62, -62, -62, -62, -61, -61, -61, -60, -60, -60, -59, -59, -59, -59, -58, -58, -58, -57, -57, -57, -57, -56, -56, -56, -55, -55, -55, -54, -54, -54, -54, -53, -53, -53, -52, -52, -52, -51, -51, -51, -51, -50, -50, -50, -49, -49, -49, -48, -48, -48, -48, -47, -47, -47, -46, -46, -46, -46, -45, -45, -45, -44, -44, -44, -43, -43, -43, -43, -42, -42, -42, -41, -41, -41, -40, -40, -40, -40, -39, -39, -39, -38, -38, -38, -38, -37, -37, -37, -36, -36, -36, -35, -35, -35, -35, -34, -34, -34, -33, -33, -33, -32, -32, -32, -32, -31, -31, -31, -30, -30, -30, -29, -29, -29, -29, -28, -28, -28, -27, -27, -27, -27, -26, -26, -26, -25, -25, -25, -24, -24, -24, -24, -23, -23, -23, -22, -22, -22, -21, -21, -21, -21, -20, -20, -20, -19, -19, -19, -19, -18, -18, -18, -17, -17, -17, -16, -16, -16, -16, -15, -15, -15, -14, -14, -14, -13, -13, -13, -13, -12, -12, -12, -11, -11, -11, -10, -10, -10, -10, -9, -9, -9, -8, -8, -8, -8, -7, -7, -7, -6, -6, -6, -5, -5, -5, -5, -4, -4, -4, -3, -3, -3, -2, -2, -2, -2, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0};
const short gyro_l_point[232]={90, 90, 90, 90, 90, 90, 90, 90, 90, 89, 89, 89, 89, 89, 89, 88, 88, 88, 88, 87, 87, 87, 86, 86, 86, 85, 85, 85, 84, 84, 83, 83, 82, 82, 82, 81, 81, 80, 80, 79, 79, 78, 78, 77, 77, 77, 76, 76, 75, 75, 74, 74, 73, 73, 73, 72, 72, 71, 71, 70, 70, 69, 69, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 64, 64, 63, 63, 62, 62, 61, 61, 60, 60, 60, 59, 59, 58, 58, 57, 57, 56, 56, 56, 55, 55, 54, 54, 53, 53, 52, 52, 51, 51, 51, 50, 50, 49, 49, 48, 48, 47, 47, 47, 46, 46, 45, 45, 44, 44, 43, 43, 43, 42, 42, 41, 41, 40, 40, 39, 39, 39, 38, 38, 37, 37, 36, 36, 35, 35, 34, 34, 34, 33, 33, 32, 32, 31, 31, 30, 30, 30, 29, 29, 28, 28, 27, 27, 26, 26, 26, 25, 25, 24, 24, 23, 23, 22, 22, 21, 21, 21, 20, 20, 19, 19, 18, 18, 17, 17, 17, 16, 16, 15, 15, 14, 14, 13, 13, 13, 12, 12, 11, 11, 10, 10, 9, 9, 8, 8, 8, 7, 7, 6, 6, 5, 5, 5, 4, 4, 4, 3, 3, 3, 2, 2, 2, 2, 1, 1, 1, 1, 1, 1, 0, 0, 0, 0, 0, 0, 0, 0, 0};
const short gyro_r_point[232]={-90, -90, -90, -90, -90, -90, -90, -90, -90, -89, -89, -89, -89, -89, -89, -88, -88, -88, -88, -87, -87, -87, -86, -86, -86, -85, -85, -85, -84, -84, -83, -83, -82, -82, -82, -81, -81, -80, -80, -79, -79, -78, -78, -77, -77, -77, -76, -76, -75, -75, -74, -74, -73, -73, -73, -72, -72, -71, -71, -70, -70, -69, -69, -69, -68, -68, -67, -67, -66, -66, -65, -65, -64, -64, -64, -63, -63, -62, -62, -61, -61, -60, -60, -60, -59, -59, -58, -58, -57, -57, -56, -56, -56, -55, -55, -54, -54, -53, -53, -52, -52, -51, -51, -51, -50, -50, -49, -49, -48, -48, -47, -47, -47, -46, -46, -45, -45, -44, -44, -43, -43, -43, -42, -42, -41, -41, -40, -40, -39, -39, -39, -38, -38, -37, -37, -36, -36, -35, -35, -34, -34, -34, -33, -33, -32, -32, -31, -31, -30, -30, -30, -29, -29, -28, -28, -27, -27, -26, -26, -26, -25, -25, -24, -24, -23, -23, -22, -22, -21, -21, -21, -20, -20, -19, -19, -18, -18, -17, -17, -17, -16, -16, -15, -15, -14, -14, -13, -13, -13, -12, -12, -11, -11, -10, -10, -9, -9, -8, -8, -8, -7, -7, -6, -6, -5, -5, -5, -4, -4, -4, -3, -3, -3, -2, -2, -2, -2, -1, -1, -1, -1, -1, -1, 0, 0, 0, 0, 0, 0, 0, 0, 0};
const short vouter_point[232]={0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 30, 29, 28, 27, 26, 25, 24, 23, 22, 21, 20, 19, 18, 17, 16, 15, 14, 13, 12, 11, 10, 9, 8, 7, 6, 5, 4, 3, 2, 1, 0};
const short vinner_point[232]={0, -1, -2, -3, -4, -5, -6, -7, -8, -9, -10, -11, -12, -13, -14, -15, -16, -17, -18, -19, -20, -21, -22, -23, -24, -25, -26, -27, -28, -29, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -30, -29, -28, -27, -26, -25, -24, -23, -22, -21, -20, -19, -18, -17, -16, -15, -14, -13, -12, -11, -10, -9, -8, -7, -6, -5, -4, -3, -2, -1, 0};
#ifndef V6_SEARCH_TURN_TABLES_H
#define V6_SEARCH_TURN_TABLES_H




#define V6_CONTINUOUS_TURN_PERCENT 90

#define V6_LEFT_TURN_TICKS 210
static const short v6_left_gyro[212]={
    90,90,89,89,88,88,88,87,87,86,86,85,85,84,84,84,83,83,
    82,82,81,81,80,80,79,79,79,79,78,78,77,77,76,76,75,75,
    75,74,74,73,73,72,72,71,71,71,70,70,69,69,69,68,68,67,
    67,67,66,66,65,65,64,64,63,63,62,62,62,61,61,60,60,59,
    59,58,58,58,58,57,57,56,56,55,55,54,54,54,53,53,52,52,
    51,51,50,50,49,49,49,48,48,48,47,47,46,46,45,45,45,44,
    44,43,43,42,42,41,41,41,40,40,39,39,38,38,37,37,37,37,
    36,36,35,35,34,34,33,33,32,32,32,31,31,30,30,29,29,28,
    28,28,27,27,26,26,26,25,25,24,24,24,23,23,22,22,21,21,
    20,20,19,19,19,18,18,17,17,16,16,16,15,15,15,14,14,13,
    13,12,12,11,11,11,10,10,9,9,8,8,7,7,6,6,6,5,
    5,5,4,4,3,3,2,2,2,1,1,0,0,0
};

static const short v6_left_outer[212]={
    63,64,65,66,66,67,68,69,70,70,71,72,73,74,74,75,76,77,
    78,78,79,80,81,82,83,83,84,85,86,87,87,88,89,90,91,91,
    92,93,94,95,95,96,97,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,97,97,96,95,94,93,93,
    92,91,90,89,88,88,87,86,85,84,84,83,82,81,80,80,79,78,
    77,76,76,75,74,73,72,71,71,70,69,68,68,68
};

static const short v6_left_inner[212]={
    63,62,61,60,60,59,58,57,56,56,55,54,53,52,52,51,50,49,
    48,48,47,46,45,44,43,43,42,41,40,39,39,38,37,36,35,35,
    34,33,32,31,31,30,29,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,29,29,30,31,32,33,33,
    34,35,36,37,38,38,39,40,41,42,42,43,44,45,46,46,47,48,
    49,50,50,51,52,53,54,55,55,56,57,58,58,58
};

#define V6_RIGHT_TURN_TICKS 215
static const short v6_right_gyro[217]={
    -90,-90,-89,-89,-88,-88,-88,-87,-87,-86,-86,-85,-85,-84,-84,-84,-83,-83,
    -82,-82,-81,-81,-80,-80,-79,-79,-79,-79,-78,-78,-77,-77,-76,-76,-75,-75,
    -75,-74,-74,-73,-73,-72,-72,-71,-71,-71,-70,-70,-69,-69,-69,-68,-68,-67,
    -67,-67,-66,-66,-65,-65,-64,-64,-63,-63,-62,-62,-62,-61,-61,-60,-60,-59,
    -59,-58,-58,-58,-58,-57,-57,-56,-56,-55,-55,-54,-54,-54,-53,-53,-52,-52,
    -51,-51,-50,-50,-49,-49,-49,-48,-48,-48,-47,-47,-46,-46,-45,-45,-45,-44,
    -44,-43,-43,-42,-42,-41,-41,-41,-40,-40,-39,-39,-38,-38,-37,-37,-37,-37,
    -36,-36,-35,-35,-34,-34,-33,-33,-32,-32,-32,-31,-31,-30,-30,-29,-29,-28,
    -28,-28,-27,-27,-26,-26,-26,-25,-25,-24,-24,-24,-23,-23,-22,-22,-21,-21,
    -20,-20,-19,-19,-19,-18,-18,-17,-17,-16,-16,-16,-15,-15,-15,-14,-14,-13,
    -13,-12,-12,-11,-11,-11,-10,-10,-9,-9,-8,-8,-7,-7,-6,-6,-6,-5,
    -5,-5,-4,-4,-3,-3,-2,-2,-2,-1,-1,0,0,1,1,2,2,2,
    2
};

static const short v6_right_outer[217]={
    63,64,65,66,66,67,68,69,70,70,71,72,73,74,74,75,76,77,
    78,78,79,80,81,82,83,83,84,85,86,87,87,88,89,90,91,91,
    92,93,94,95,95,96,97,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,
    98,98,98,98,98,98,98,98,98,98,98,97,97,96,95,94,93,93,
    92,91,90,89,88,88,87,86,85,84,84,83,82,81,80,80,79,78,
    77,76,76,75,74,73,72,71,71,70,69,68,67,67,66,65,64,64,
    64
};

static const short v6_right_inner[217]={
    63,62,61,60,60,59,58,57,56,56,55,54,53,52,52,51,50,49,
    48,48,47,46,45,44,43,43,42,41,40,39,39,38,37,36,35,35,
    34,33,32,31,31,30,29,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,28,
    28,28,28,28,28,28,28,28,28,28,28,29,29,30,31,32,33,33,
    34,35,36,37,38,38,39,40,41,42,42,43,44,45,46,46,47,48,
    49,50,50,51,52,53,54,55,55,56,57,58,59,59,60,61,62,62,
    62
};

#endif


void sim_tick(void){
    int move=1;
    if(++sim_steps>200000)longjmp(escape,999);
    if(task==TURN || task==TURNAROUND || task==POINTTURN90){
        move=0;gangle=(task==TURN || step==0)?turn_gyro[tick+1]:0;
    }else if(task==STOP){move=track<0?1:0;gangle=0;}
    else if(task==BEFORE180TURN || task==KEEPWALLDISTANCE){
        int target=task==BEFORE180TURN?20:keep_dis;
        move=disf>target?1:(disf<target?-1:0);gangle=0;
    }
    track+=move;absolutetrack+=move;
    speedl=speedr=move?1:0;speed=move?speed_turn:0;
    if(front_plane){disf=disf1=disf2=front_plane-absolutetrack;}
    switch(task){
case ACC:				 
 
		eh=e;
		e=gangle;
		 
		setvl=accratio*track+ACCV0;
		setvr=setvl;
		 
		setvl-=e*2.5+(e-eh)*1.6;
		setvr+=e*2.5+(e-eh)*1.6;
		break;
	
 
	
case STOP:				 
 
		 
		eh=e;
		e=gangle;	   
		 
		setvl=-decratio*track;
		setvr=setvl;
		 
		setvl-=e*2.5+(e-eh)*1.6;
		setvr+=e*2.5+(e-eh)*1.6;
		if(track<2&&track>-2&&speedl<2&&speedr<2&&speedl>-2&&speedr>-2) tick++;
		else tick=0;
		stoptick++;
		break;
	
 
	
case TURN:
 
		setgangle=*(turn_gyro+tick);	 	 
		eh=e;
		e=gangle-setgangle;
		tick++;
		setvl=*(turn_vl+tick)-e*turn_kp-(e-eh)*turn_kd; 
		setvr=*(turn_vr+tick)+e*turn_kp+(e-eh)*turn_kd;             
		break;
	
 
	
case TURNAROUND:		 
 
		if(step==0)
		{
			tick++;	 		
			setgangle=*(turn_gyro+tick);	 	 
			eh=e;
			e=gangle-setgangle;
 
			esum+=e;		
			setvl=*(turn_vl+tick)-e*2.5-esum*0.01-(e-eh)*0.1;
			setvr=*(turn_vr+tick)+e*2.5+esum*0.01+(e-eh)*0.1;
			if(tick>200){step=1;tick=0;}                
			turnaround_tick = 0;
		}
		else if(step==1)
		{
			eh=e;
			e=gangle;
			setvl=-e*2.5-(e-eh)*0.1;	 
			setvr=e*2.5+(e-eh)*0.1;
			if(speedl<2&&speedr<2&&speedl>-2&&speedr>-2)tick++; 
			else tick=0;
 
 
		}
		break;
		
 
	
case POINTTURN90:		 
 
		if(step==0)
		{
			tick++;	 		
			setgangle=*(turn_gyro+tick);	 	 
			eh=e;
			e=gangle-setgangle;	   
			esum+=e;		
			setvl=*(turn_vl+tick)-e*2.5-esum*0.01-(e-eh)*0.1; 
			setvr=*(turn_vr+tick)+e*2.5+esum*0.01+(e-eh)*0.1;
			if(tick>30){step=1;tick=0;}             
			turnaround_tick = 0;
		}
		else if(step==1)
		{	 	 
			e=gangle;
			setvl=e*(-1);	 
			setvr=e*1;
			if(speedl<10&&speedr<10&&speedl>-10&&speedr>-10)tick++;    
			else tick=0;
		}
		break;
		
 
	
case BEFORE90TURN:
 
		if(forwardhaswall==1) 
		{			 
			e=disf2-disf1;
			setvl=speed_turn-e*0.1;
			setvr=speed_turn+e*0.1;
		}
		else 
		{
			e=gangle;
			setvl=speed_turn-e*0.6; 
			setvr=speed_turn+e*0.6;
		}
		 
		{
 
 
		}
		break;
		
 
#ifndef MOUSE_REMOTE
    case V5_FRONT_RECHECK_TASK:
        if(v5_diag.hold_ticks<65535)v5_diag.hold_ticks++;
        setvl=0;setvr=0;
        break;
#endif
	
case BEFORE180TURN:
 
		if(righthaswall==1 && lefthaswall==0 && disf>60) 
		{
			setvl=speed_turn+(disr-dis2wall);
			setvr=speed_turn-(disr-dis2wall);	
		}
		else if(righthaswall==0 && lefthaswall==1 && disf>60)
		{
			setvl=speed_turn-(disl-dis2wall);
			setvr=speed_turn+(disl-dis2wall);	
		}
		else if(righthaswall==1 && lefthaswall==1 && disf>60)
		{
			setvl=speed_turn+(disr-disl);
			setvr=speed_turn-(disr-disl);	
		}
		else
		{
			setvl=(disf-20)*0.5+(disf1-20)*1;			 
			setvr=(disf-20)*0.5+(disf2-20)*1;
			if(setvl>speed_turn) setvl=speed_turn;
			if(setvl<-speed_turn) setvl=-speed_turn;
			if(setvr>speed_turn) setvr=speed_turn;
			if(setvr<-speed_turn) setvr=-speed_turn;
			if( (disf-20)<-20 && abs(disf1-disf2)<100 )	 
			{
				setvl=-speed_turn;
				setvr=-speed_turn;
			}
			if( (disf-20)>20 && abs(disf1-disf2)<100 )
			{
				setvl=speed_turn;
				setvr=speed_turn;
			}
			if(speedl<2&&speedr<2&&speedl>-2&&speedr>-2)tick++;
			else tick=0;
			turnaround_tick++;
			if(turnaround_tick>100)tick=100; 
		}
#ifndef MOUSE_REMOTE
        if(v5_diag.deadend_limit_active && disf>60 &&
           (lefthaswall || righthaswall))
        {
            long correction=(setvl-setvr)/2;
            long bound=speed_turn/V5_DEADEND_CORRECTION_DIVISOR;
            if(correction>bound)correction=bound;
            if(correction<-bound)correction=-bound;
            setvl=speed_turn+correction;setvr=speed_turn-correction;
        }
#endif
		break;
		
 
	
case KEEPWALLDISTANCE:


		setvl=(disf-keep_dis)*0.5+(disf1-keep_dis)*1;				 
		setvr=(disf-keep_dis)*0.5+(disf2-keep_dis)*1;
		if(setvl>50) setvl=50;
		if(setvl<-50) setvl=-50;
		if(setvr>50) setvr=50;
		if(setvr<-50) setvr=-50;
		if( (disf-keep_dis)<-20 && abs(disf1-disf2)<100 )
		{
			setvl=-50;
			setvr=-50;
		}
		if( (disf-keep_dis)>20 && abs(disf1-disf2)<100 )
		{
			setvl=50;
			setvr=50;
		}
		if(speedl<2&&speedr<2&&speedl>-2&&speedr>-2)tick++;
		else tick=0;
		turnaround_tick++;
		if(turnaround_tick>500)tick=100;		
		break;
		
 
 
 
 
 
		
		
 
	
case GOSTRAIGHT:			 
 
		eh=e;
		e=gangle;
		setvl=speed_ss-e*GOSTRAIGHT_kp; 
		setvr=speed_ss+e*GOSTRAIGHT_kp; 
		break;
	
 
	
case SMARTSTRAIGHT:			 
 
		if(lefthaswall==0 && righthaswall==0) 
		{
			eh=e;
			e=gangle;
			setvl=speed_turn-e*1;		 
			setvr=speed_turn+e*1;
		}
		else if(lefthaswall==1)
		{
			eh=e;
			e=disl-dis2wall;
			setvl=speed_turn-e*0.1;		
			setvr=speed_turn+e*0.1;
		}
		else if(righthaswall==1)
		{
			eh=e;
			e=dis2wall-disr;
			setvl=speed_turn-e*0.1;		
			setvr=speed_turn+e*0.1;
		}
		break;
		
 
	
case SMARTSTRAIGHTFAST:		 
 
		if(lefthaswall==0 && righthaswall==0) 
		{
			eh=e;
			e=gangle;
			setvl=speed_ss-e*1;		
			setvr=speed_ss+e*1;
		}
		else
		{
			if((lastside==LEFT && lefthaswall==1) || (lastside==RIGHT && righthaswall==0)) 
			{
				lastside=LEFT;
				eh=e;				  
				e=disl-dis2wall;
				if(abs(e)>10)
				{
					setvl=speed_ss-e*SMARTSTRAIGHTFAST_bigerror_kp-(e-eh)*0.16; 
					setvr=speed_ss+e*SMARTSTRAIGHTFAST_bigerror_kp+(e-eh)*0.16; 
				}
				else
				{
					setvl=speed_ss-e*SMARTSTRAIGHTFAST_smallerror_kp-(e-eh)*0.1; 
					setvr=speed_ss+e*SMARTSTRAIGHTFAST_smallerror_kp+(e-eh)*0.1; 
				}
			}
			else
			{
				lastside=RIGHT;			  
				eh=e;
				e=dis2wall-disr;
				if(abs(e)>10)
				{
					setvl=speed_ss-e*SMARTSTRAIGHTFAST_bigerror_kp-(e-eh)*0.16; 
					setvr=speed_ss+e*SMARTSTRAIGHTFAST_bigerror_kp+(e-eh)*0.16; 
				}
				else
				{
					setvl=speed_ss-e*SMARTSTRAIGHTFAST_smallerror_kp-(e-eh)*0.1; 
					setvr=speed_ss+e*SMARTSTRAIGHTFAST_smallerror_kp+(e-eh)*0.1; 
				}
			}		
		}
		 
		break;
		
 
	
case STRAIGHTEYECLOSECOORADJ:	 
 
		eh=e;
		e=gangle;
		setvl=speed_ss-e*0.25;		
		setvr=speed_ss+e*0.25;
		#ifdef COORADJUST
		 
		 
		{												
			if(lefthaswallh==1&&lefthaswall==0){settrack(trackcoor);}
			if(righthaswallh==1&&righthaswall==0){settrack(trackcoor);}
		}
		#endif
		break;
		
 
	case STRAIGHTPOLE:			 
 
 
 
 
 
 
 
 
 
		e=gangle;
		setvl=speed_ss-e*0.5;		
		setvr=speed_ss+e*0.5;

		#ifdef COORADJUST
		 
		{
			if(lefthaswallh==1 && lefthaswall==0) settrack(trackcoor);
			if(righthaswallh==1 && righthaswall==0) settrack(trackcoor);
		}
		#endif
		break;	

 
 
 
 
 
 
 
	
    default:break;
    }
    if(departure_calls && departure_end<0 && task==SMARTSTRAIGHT &&
       post_left==0 && post_right==0 && (setvl!=speed_turn || setvr!=speed_turn))command_errors++;
}

static void v5CaptureStop(volatile V5_STOP_SNAPSHOT *s)
{
    s->sample_seq=v5_diag.sample_seq;
    s->track=track;s->absolute_track=absolutetrack;
    s->front1=disf1;s->front2=disf2;s->front_mean=disf;
    s->left=disl;s->right=disr;
    s->filtered_adc_f1=rawf1;s->filtered_adc_f2=rawf2;
    s->filtered_adc_l=rawl;s->filtered_adc_r=rawr;
    s->target_l=setvl;s->target_r=setvr;
    s->speed_l=speedl;s->speed_r=speedr;s->yaw=gangle;
    s->task=task;s->last_action=LastSearchAction;
    s->x=GmcMouse.cX;s->y=GmcMouse.cY;s->direction=GucMouseDir;
    s->left_wall=lefthaswall;s->right_wall=righthaswall;s->front_wall=forwardhaswall;
    s->front_adc1=v5_diag.front_adc1;s->front_adc2=v5_diag.front_adc2;
}
static void v5PrintSnapshot(const char *label,volatile V5_STOP_SNAPSHOT *s)
{
    printf("V5_%s seq=%lu task=%u last=%u xy=%u,%u dir=%u walls=%u,%u,%u\r\n",
           label,s->sample_seq,s->task,s->last_action,s->x,s->y,s->direction,
           s->left_wall,s->right_wall,s->front_wall);
    printf("V5_%s_IR adc=%u,%u filtered=%d,%d side_adc=%d,%d dist=%ld,%ld mean=%ld side=%ld,%ld\r\n",
           label,s->front_adc1,s->front_adc2,s->filtered_adc_f1,s->filtered_adc_f2,
           s->filtered_adc_l,s->filtered_adc_r,s->front1,s->front2,s->front_mean,s->left,s->right);
    printf("V5_%s_MOTION track=%ld absolute=%ld target=%ld,%ld speed=%d,%d yaw=%d\r\n",
           label,s->track,s->absolute_track,s->target_l,s->target_r,s->speed_l,s->speed_r,s->yaw);
}
static void v5PrintStop(void)
{
    printf("V5_STOP event=%u source=%u result=%u recovered=%u persistent=%u\r\n",
           v5_diag.events,v5_diag.source,v5_diag.result,v5_diag.recovered,v5_diag.persistent);
    v5PrintSnapshot("TRIGGER",&v5_diag.last);
    v5PrintSnapshot("RECHECK",&v5_diag.recheck);
}
static u8 v5FrontClear(void)
{
    
    return (disf1>=V5_FRONT_CLEAR && disf1<=249 &&
            disf2>=V5_FRONT_CLEAR && disf2<=249 &&
            disf==(disf1+disf2)/2);
}
static u8 v5FrontRecheck(u8 source)
{
    u32 mask,seen;
    u16 stable=0,stopped=0;
    u8 previous_task,previous_flash,printed=0;

    mask=__get_PRIMASK();__disable_irq();
    if(disf>=V5_FRONT_TRIP)
    {
        if(!mask)__enable_irq();
        return 1;
    }
    previous_task=task;previous_flash=flashwrite;
    v5CaptureStop(&v5_diag.last);
    if(v5_diag.magic!=V5_DIAG_MAGIC)
    {
        v5_diag.magic=V5_DIAG_MAGIC;v5_diag.events=0;
        v5_diag.recovered=0;v5_diag.persistent=0;
    }
    if(v5_diag.events==0)v5_diag.first=v5_diag.last;
    if(v5_diag.events<65535)v5_diag.events++;
    v5_diag.source=source;v5_diag.result=V5_DIAG_PENDING;
    v5_diag.active=1;v5_diag.hold_ticks=0;
    task=V5_FRONT_RECHECK_TASK;setvl=0;setvr=0;flashwrite=0;
    seen=v5_diag.sample_seq;
    if(!mask)__enable_irq();

    
    while(v5_diag.hold_ticks<V5_RECHECK_MAX_TICKS)
    {
        if(sleepmode || isemergency || task!=V5_FRONT_RECHECK_TASK)break;
        if(seen==v5_diag.sample_seq)continue;
        mask=__get_PRIMASK();__disable_irq();
        seen=v5_diag.sample_seq;
        if(speedl>-2 && speedl<2 && speedr>-2 && speedr<2)
        {
            if(stopped<V5_RECHECK_STABLE_SAMPLES)stopped++;
            if(v5FrontClear())stable++;else stable=0;
        }
        else {stopped=0;stable=0;}
        if(stopped>=V5_RECHECK_STABLE_SAMPLES && !printed)
        {
            v5CaptureStop(&v5_diag.recheck);
            if(!mask)__enable_irq();
            
            v5PrintStop();printed=1;stable=0;
            seen=v5_diag.sample_seq;
            continue;
        }
        if(printed && stable>=V5_RECHECK_STABLE_SAMPLES &&
           v5_diag.hold_ticks>=V5_RECHECK_MIN_TICKS &&
           !sleepmode && !isemergency && task==V5_FRONT_RECHECK_TASK)
        {
            v5CaptureStop(&v5_diag.recheck);
            v5_diag.result=V5_DIAG_RECOVERED;
            if(v5_diag.recovered<65535)v5_diag.recovered++;
            v5_diag.active=0;e=0;eh=0;
            flashwrite=previous_flash;task=previous_task;
            if(!mask)__enable_irq();
            return 1;
        }
        if(!mask)__enable_irq();
    }
    mask=__get_PRIMASK();__disable_irq();
    v5CaptureStop(&v5_diag.recheck);
    v5_diag.result=(sleepmode || isemergency || task!=V5_FRONT_RECHECK_TASK)?
                   V5_DIAG_ABORTED:V5_DIAG_PERSISTENT;
    if(v5_diag.persistent<65535)v5_diag.persistent++;
    v5_diag.active=0;task=NULL;setvl=0;setvr=0;flashwrite=0;
    if(!mask)__enable_irq();
    v5PrintStop();
    return 0;
}
static u8 v6UseSlowSearchTurn(void)
{
    return (GucMouseTask==MAZESEARCH && spurt_search_active!=1 &&
            V6_TURN_CHAIN==1 &&
            (LastSearchAction==TurnLeft || LastSearchAction==TurnRight));
}
static void v6SlowSearchTurn90(u8 direction)
{
    u16 end_tick;int profile_index=turn_count;
turn_codes[turn_count]=direction==TurnLeft?LT90SEARCH:RT90SEARCH;turn_at[turn_count]=(int)absolutetrack;entry_speed[turn_count]=speed_turn;entry_previous[turn_count]=LastSearchAction;entry_coor_count[turn_count]=coor_count;profile_slow[turn_count]=1;turn_count++;
    eh=0;e=0;esum=0;tick=0;
    if(direction==TurnLeft)
    {
        setangle(-90);
        turn_gyro=v6_left_gyro;turn_vl=v6_left_inner;turn_vr=v6_left_outer;
        end_tick=V6_LEFT_TURN_TICKS;
    }
    else
    {
        setangle(90);
        turn_gyro=v6_right_gyro;turn_vl=v6_right_outer;turn_vr=v6_right_inner;
        end_tick=V6_RIGHT_TURN_TICKS;
    }
    task=TURN;
    while(tick<end_tick){sim_tick();}
    capture_profile(profile_index);settrack(0);gangle=0;
}
void parameter_search(void)
{
	kpl=13;kil=0.74;kdl=0.9;	
	kpr=13;kir=0.74;kdr=0.9;	
	speed_ss = 80;		
	
	keep_dis = 12;		
	turn_delay = 9;	
}
void parameter_spurt(void)
{
	kpl=13;kil=0.7;kdl=0.8;	
	kpr=13;kir=0.7;kdr=0.8;	
	speed_ss = 100;		
	speed_turn = 70;	
	keep_dis = 12;		
	turn_delay = 0;	
}
void settrack(int t) 
{
	basetrack=absolutetrack-t;
	track=t;
}
void taskacc()
{acc_calls++;
	settrack(0);
	e=0;eh=0;
 	accratio=(double)(speed_turn-ACCV0)/accdistance; 
	while(track<accdistance){task=ACC;sim_tick();}
acc_end=(int)absolutetrack;
}
void taskstop()
{
	settrack(-decdistance);
	eh=0;
	e=0;
	tick=0;
	stoptick=0;
	decratio=(double)speed/decdistance;	
	while(tick<3)
	{
		task=STOP;sim_tick();
		if(stoptick>30) break; 
	}
	settrack(0);
}
void taskgostraight(u16 dis)
{
	eh=0;
	e=0;
	while(track<dis){task=GOSTRAIGHT;sim_tick();}
}
void taskturn(u8 pattern)
{
	u16 length;int profile_index=turn_count;profile_slow[turn_count]=0;
turn_codes[turn_count]=pattern;turn_at[turn_count]=(int)absolutetrack;entry_speed[turn_count]=speed_turn;entry_previous[turn_count]=LastSearchAction;entry_coor_count[turn_count]=coor_count;turn_count++;
	eh=0;
	e=0;
	esum=0;
	tick=0;		
	switch(pattern)
	{
		case LT90SPURT:
			setangle(-90);
			turn_gyro=gyro_l_spurt;turn_vl=vinner_spurt;turn_vr=vouter_spurt;
			length=sizeof(gyro_l_spurt);
			break;
		case RT90SPURT:
			setangle(90);
			turn_gyro=gyro_r_spurt;turn_vl=vouter_spurt;turn_vr=vinner_spurt;
			length=sizeof(gyro_r_spurt);	
			break;
		case LT90SEARCH:
			setangle(-90);
			turn_gyro=gyro_l_search;turn_vl=vinner_search;turn_vr=vouter_search;
			length=sizeof(gyro_l_search)-8;
#ifndef MOUSE_REMOTE
            
            if(spurt_search_active==1 && spurt_exec_index==200)
                length=sizeof(gyro_l_search);
#endif
			break;
		case RT90SEARCH:
			setangle(90);
			turn_gyro=gyro_r_search;turn_vl=vouter_search;turn_vr=vinner_search;
			length=sizeof(gyro_r_search);	
			break;
		case POINTL90:
			setangle(-90);
			turn_gyro=gyro_l_point;turn_vl=vinner_point;turn_vr=vouter_point;
			length=sizeof(gyro_l_point)-2;
			break;
		case POINTR90:
			setangle(90);
			turn_gyro=gyro_r_point;turn_vl=vouter_point;turn_vr=vinner_point;
			length=sizeof(gyro_r_point);	
			break;
		#ifdef LOW_ENABLE
		case LT90L:
			setangle(-90);
			turn_gyro=gyro_lt90_low;turn_vl=vinner_t90_low;turn_vr=vouter_t90_low;
			length=sizeof(gyro_lt90_low)-16;
			break;
		case RT90L:
			setangle(90);
			turn_gyro=gyro_rt90_low;turn_vl=vouter_t90_low;turn_vr=vinner_t90_low;
			length=sizeof(gyro_rt90_low)-4;	
			break;
		case LV90L: 
			setangle(-90);
			turn_gyro=gyro_lv90_low;turn_vl=vinner_v90_low;turn_vr=vouter_v90_low;
			length=sizeof(gyro_lv90_low);	
			break;
		case RV90L: 
			setangle(90);
			turn_gyro=gyro_rv90_low;turn_vl=vouter_v90_low;turn_vr=vinner_v90_low;
			length=sizeof(gyro_rv90_low);	
			break;
		case LT45L: 
			setangle(-45);
			turn_gyro=gyro_lt45_low;turn_vl=vinner_t45_low;turn_vr=vouter_t45_low;
			length=sizeof(gyro_lt45_low);	
			break;
		case RT45L: 
			setangle(45);
			turn_gyro=gyro_rt45_low;turn_vl=vouter_t45_low;turn_vr=vinner_t45_low;
			length=sizeof(gyro_rt45_low);	
			break;
		case LV45L: 
			setangle(-45);
			turn_gyro=gyro_lv45_low;turn_vl=vinner_v45_low;turn_vr=vouter_v45_low;
			length=sizeof(gyro_lv45_low)-14;	
			break;
		case RV45L: 
			setangle(45);
			turn_gyro=gyro_rv45_low;turn_vl=vouter_v45_low;turn_vr=vinner_v45_low;
			length=sizeof(gyro_rv45_low)-8;	
			break;
		case LT135L: 
			setangle(-135);
			turn_gyro=gyro_lt135_low;turn_vl=vinner_t135_low;turn_vr=vouter_t135_low;
			length=sizeof(gyro_lt135_low);	
			break;
		case RT135L: 
			setangle(135);
			turn_gyro=gyro_rt135_low;turn_vl=vouter_t135_low;turn_vr=vinner_t135_low;
			length=sizeof(gyro_rt135_low);	
			break;
		case LV135L: 
			setangle(-135);
			turn_gyro=gyro_lv135_low;turn_vl=vinner_v135_low;turn_vr=vouter_v135_low;
			length=sizeof(gyro_lv135_low);	
			break;
		case RV135L: 
			setangle(135);
			turn_gyro=gyro_rv135_low;turn_vl=vouter_v135_low;turn_vr=vinner_v135_low;
			length=sizeof(gyro_rv135_low)+8;	
			break;
		case L180L: 
			setangle(-180);
			turn_gyro=gyro_l180_low;turn_vl=vinner_180_low;turn_vr=vouter_180_low;
			length=sizeof(gyro_l180_low);	
			break;		 
		case R180L:
			setangle(180);
			turn_gyro=gyro_r180_low;turn_vl=vouter_180_low;turn_vr=vinner_180_low;
			length=sizeof(gyro_r180_low);	
			break;
		#endif
	}
	task=TURN;
    while(tick<length/2-2)
    {sim_tick();
        if(spurt_search_active==1 && !spurtSearchRunning())
        {
            task=NULL;setvl=0;setvr=0;
            return;
        }
    }
	settrack(0);
capture_profile(profile_index);gangle=0;
}
void taskturnaround()
{ 
	if(GmcMouse.cX==0&&GmcMouse.cX==0)
	{
		taskgostraight(30);
	}
	setangle(180);
	turn_gyro=gyro_around;
	turn_vl=vl_around;
	turn_vr=vr_around;
	eh=0;
	e=0;
	tick=0;step=0;
	task=TURNAROUND;
	while(1){sim_tick();if(step==1 && tick>30)break;} 
	settrack(0);	
pivot_at=(int)absolutetrack;pivot_count++;exit_sensors();
}
void taskpointturnright()
{point_calls++;
	setangle(90);
	turn_gyro=gyro_r_point;
	turn_vl=vouter_point;
	turn_vr=vinner_point;
	eh=0;
	e=0;
	tick=0;step=0;
	task=POINTTURN90;
	while(1){sim_tick();if(step==1 && tick>10)break;}
	settrack(0);	
}
void taskpointturnleft()
{point_calls++;
	setangle(-90);
	turn_gyro=gyro_l_point;
	turn_vl=vinner_point;
	turn_vr=vouter_point;
	eh=0;
	e=0;
	tick=0;step=0;
	task=POINTTURN90;
	while(1){sim_tick();if(step==1 && tick>10)break;}
	settrack(0);	
}
void before180turn()			 
{
	settrack(0);
	task=SMARTSTRAIGHT;
	while(track<5){sim_tick();}				 
	if(lefthaswall==1) afterturn_flag=1;
	else if(righthaswall==1) afterturn_flag=2;
		else afterturn_flag=0;
	while(track<5){sim_tick();}

	if(forwardhaswall==0)			 
	{
	if(LastSearchAction==Stright) taskgostraight(5);	 
		else taskgostraight(20);	 
		disbf180=absolutetrack;
		decdistance=10; taskstop(); decdistance=10;
		disbf180=absolutetrack-disbf180+30;				 
	}
	else if(forwardhaswall==1) 
	{					   
		tick=0;
		turnaround_tick=0;
		taskgostraight(10);
		task=BEFORE180TURN;
	 	while(tick<5){sim_tick();}
		disbf180=90;
	}

	settrack(0);
	LastSearchAction=TURN180;
}
void after180turn()				 
{
 

 






	 if(afterturn_flag==2)
		{
			taskturn(POINTL90);
			tick=0;
			turnaround_tick=0;
			task=KEEPWALLDISTANCE;
			while(tick<10){sim_tick();}
			 
			taskpointturnright();
			taskacc();			 
			taskgostraight(disbf180-35);
		}
		else if(afterturn_flag==1)
			{
				taskturn(POINTR90);
				tick=0;
				turnaround_tick=0;
				task=KEEPWALLDISTANCE;
				while(tick<10){sim_tick();}
				 
				taskpointturnleft();
				taskacc();
				taskgostraight(disbf180-35);
			}
			else 
			{
				taskacc();			 
				taskgostraight(disbf180-35);	
			}
	afterturn_flag=0;
}
void mouseTurnback()
{				
	goaheadbugflag=0;
	before180turn();
	LastSearchAction=Stright;
	taskturnaround();
	if(block_write_flag==1)
	{
		SaveBlockData(); 
		block_write_flag=0;
	}
		if((GmcMouse.cX!=GoalX)||(GmcMouse.cY!=GoalY))
		{
	after180turn();
		}
	GucMouseDir = (GucMouseDir + 2) % 4;
	__mouseCoorUpdate();
	settrack(0);
}
void specialmouseTurnback()
{				
	goaheadbugflag=0;
	before180turn();
	taskturnaround();
	GucMouseDir = (GucMouseDir + 2) % 4;
	settrack(0);
}
void mazeSearch()				 
{	
	if(goaheadbugflag==1) goaheadbugflag=0; 
	eh=0;
	e=0;
	gangleh=0;
	ganglehh=0;
	peakgangle=0;
	peakgangleh=0;
	task=SMARTSTRAIGHT;
	 
	while(1){if(track>90 && track<180)sim_tick();
#ifdef MOUSE_REMOTE
		if (LP_AbortRequested()) break; 
#endif
		if(track>=180) 
		{	
			blocknum++; 
			 
			settrack(0);
			if(goaheadbugflag==0) __mouseCoorUpdate();
			if(breakornot()==1){blocknum=1;break;}
		}
		if(track>90 && track<180); 
		else
		{		  
			if(lefthaswall==1 || righthaswall==1) mazesearchhaswall(); 
			else if(lefthaswall==0 && righthaswall==0) mazesearchnowall();
		}
	}
}
u8 breakornot() 
{
	if(forwardhaswall==1)return 1;
	else if(lefthaswall==0)return 1;
	else if(righthaswall==0)return 1;
	else return 0;
}
void before90turn(u8 Direction)				 
{
 
 
 
		e=0;eh=0;
		task=BEFORE90TURN;
#ifndef MOUSE_REMOTE
        
        if(spurt_search_active==1 && spurt_exec_index==200)
        {
            while(track<turn_delay)
            {sim_tick();
                if(!spurtSearchRunning() || disf<10)
                {
                    spurt_search_failed=1;
                    return;
                }
            }
            turno=0;
            return;
        }
#endif
		while(1){sim_tick();
			if(spurt_search_active==1 && !spurtSearchRunning()) return;
 
		
			if(LastSearchAction==TURN180)					 
			{
				if(Direction==TurnLeft)						 
				{
					if(track>=turn_delay+27) 
					{
						turno=0; break;
					}
				}
				else
				{
					if(track>=turn_delay+20)						 
					{
						turno=0; break;
					}
				}
			} 
			
			
			if(LastSearchAction==Stright)					 
			{
				if(Direction==TurnLeft)						 
				{
					if(track>=turn_delay-2)
					{
						turno=0; break;
					}
				}
				else
				{
					if(track>=turn_delay-3)						 
					{
						turno=0; break;
					}
				}
			}
			else if(LastSearchAction==TurnLeft)
			{
				if(Direction==TurnLeft)						 
				{
					if(track>=turn_delay)
					{
						turno=0; break;
					}
				}
				else
				{
					if(track>=turn_delay-5)						  
					{
						turno=0; break;
					}
				}
			}
			else if(LastSearchAction==TurnRight)
			{
				if(Direction==TurnLeft)					 
				{
					if(track>=turn_delay-4)    
					{
						turno=0; break;
					}
				}
				else
				{
					if(track>=turn_delay-1)						 
					{
						turno=0; break;
					}
				}
			}
		}
 
}
void mouseTurnright()
{	 
	goaheadbugflag=0;
	before90turn(TurnRight);
	if(spurt_search_active==1 && (!spurtSearchRunning() || disr<50))
	{
		spurt_search_failed=1;
		return;
	}
	LastSearchAction=TurnRight;
	if(lefthaswall==1)
	{
		turnrighto=dis2wall-((disl+dislh+dislhh)/3);
		turno=(disr+disrh+disrhh)/3-dis2wall;
	}
	else {turnrighto=0;turno=0;}
	if(disr<50) 
	{
		flashwrite=0;
	 	setvl=0;setvr=0;
		task=NULL;
		delay_ms(50);
		sleepmode=1;
		while(1){sleepmode=1;ledoff(0);delay_ms(500);ledon(7);ledon(8);delay_ms(500);}
	}
	taskturn(RT90SEARCH);
	if(spurt_search_active==1 && !spurtSearchRunning()) return;
	task=SMARTSTRAIGHT;
	GucMouseDir=(GucMouseDir + 1) % 4; 
	settrack(180-turnrighto); 

 
}
void mouseTurnleft()
{	 
	goaheadbugflag=0;
	before90turn(TurnLeft);
	if(spurt_search_active==1 && (!spurtSearchRunning() || disl<50))
	{
		spurt_search_failed=1;
		return;
	}
	LastSearchAction=TurnLeft;
	if(righthaswall==1)
	{
		turnlefto=(disr+disrh+disrhh)/3-dis2wall;
		turno=(disr+disrh+disrhh)/3-dis2wall;
	}
	else {turnlefto=0;turno=0;}
	if(disl<50) 
	{
	 	flashwrite=0;
		setvl=0;setvr=0;
		task=NULL;
	delay_ms(50);
		sleepmode=1;
		while(1){sleepmode=1;ledoff(0);delay_ms(500);ledon(5);ledon(6);delay_ms(500);}
	}		   	
	taskturn(LT90SEARCH);
	if(spurt_search_active==1 && !spurtSearchRunning()) return;
	task=SMARTSTRAIGHT;
	GucMouseDir=(GucMouseDir + 3) % 4;
	settrack(180+turnlefto);


}
void mazesearchhaswall()		 
{
	turno=0;
	if(disf<10) 
	{
	 	flashwrite=0;
		setvl=0;setvr=0;
		task=NULL;
		delay_ms(300);
	sleepmode=1;
#ifdef MOUSE_REMOTE
	while(1){if (LP_AbortRequested()) return; sleepmode=1;ledoff(0);delay_ms(500);ledon(1);ledon(2);delay_ms(500);}
#else
	while(1){sleepmode=1;ledoff(0);delay_ms(500);ledon(1);ledon(2);delay_ms(500);}
#endif
	}
	
	if(LastSearchAction!=Stright) settrack(track+20);	 
	LastSearchAction=Stright;
	 
	while(track<120+8){task=SMARTSTRAIGHTFAST;sim_tick();}			 
	eh=0;e=0;
	while(track<180){task=STRAIGHTEYECLOSECOORADJ;sim_tick();}		 
}
void mazesearchnowall()			 
{
	turno=0;
	if(disf<10) 
	{
	 	flashwrite=0;
		setvl=0;setvr=0;
		task=NULL;
		delay_ms(300);
		sleepmode=1;
#ifdef MOUSE_REMOTE
	while(1){if (LP_AbortRequested()) return; sleepmode=1;ledoff(0);delay_ms(500);ledon(3);ledon(4);delay_ms(500);}
#else
		while(1){sleepmode=1;ledoff(0);delay_ms(500);ledon(3);ledon(4);delay_ms(500);}
#endif
	}
	if(LastSearchAction!=Stright) settrack(track+20);
	LastSearchAction=1;
	 

	while(track<120+8){task=GOSTRAIGHT;sim_tick();}

	dislpeak=200;
	disrpeak=200;
	lpeakfindenable=0;
	rpeakfindenable=0;
	leftpeaktrack=0;
	rightpeaktrack=0;
	tick=0;
	task=STRAIGHTPOLE;
	while(track<180){sim_tick();} 
}
void mouseGoahead(char cNBlock)	 
{	   
	u8 n=0;			 
	goaheadbugflag=1;
	eh=0;
	e=0;
	gangleh=0;
	ganglehh=0;
	peakgangle=0;
	peakgangleh=0;
	task=SMARTSTRAIGHT;
	while(1){if(track>90 && track<180)sim_tick();
#ifdef MOUSE_REMOTE
		if (LP_AbortRequested()) break; 
#endif
		if(track>=180) 
		{	
			blocknum++; 
			settrack(0);
			__mouseCoorUpdate();
			n++;
			if(n==cNBlock)
			{
				blocknum=1;
				break;
			}
		}
		if(track>90&&track<180); 
		else
		{	  
			if(lefthaswall==1 || righthaswall==1) mazesearchhaswall();	 
			else if(lefthaswall==0 && righthaswall==0) mazesearchnowall();
		}
	}
}
void __mouseCoorUpdate (void)
{	 
    switch (GucMouseDir) {

    case 0:
        GmcMouse.cY++;
        break;

    case 1:
        GmcMouse.cX++;
        break;

    case 2:
        GmcMouse.cY--;
        break;

    case 3:
        GmcMouse.cX--;
        break;

    default:
        break;
    }
 
	 
    __wallCheck();
	 
}
static u8 spurtSearchRunning(void)
{
#ifdef MOUSE_REMOTE
    if(LP_AbortRequested()) return 0;
#endif
    return (isemergency==0 && sleepmode==0 && spurt_search_failed==0);
}
void mapStepEdit (char  cX, char  cY)
{
    uchar n         = 0;                                                 
    uchar ucStep    = 0;                                                 
    uchar ucStat    = 0;                                                 
    uchar i,j;
    
    GmcStack[n].cX  = cX;                                                
    GmcStack[n].cY  = cY;                                                
    n++;
     
    for (i = 0; i < MAZETYPE; i++)
	{
        for (j = 0; j < MAZETYPE; j++)
		{
            GucMapStep[i][j] = 0xff;
        }
    }
     
    while (n)
	{
#ifdef MOUSE_REMOTE
        
        if (LP_AbortRequested()) return;
#endif
        GucMapStep[cX][cY] = ucStep++;                                   

         
        ucStat = 0;
        if ((GucMapBlock[cX][cY] & 0x01) &&                              
            (GucMapStep[cX][cY + 1] > (ucStep))) {                       
            ucStat++; 
        }
        if ((GucMapBlock[cX][cY] & 0x02) &&                              
            (GucMapStep[cX + 1][cY] > (ucStep))) {                       
            ucStat++;                                                    
        }
        if ((GucMapBlock[cX][cY] & 0x04) &&
            (GucMapStep[cX][cY - 1] > (ucStep))) {
            ucStat++;                                                    
        }
        if ((GucMapBlock[cX][cY] & 0x08) &&
            (GucMapStep[cX - 1][cY] > (ucStep))) {
            ucStat++;                                                    
        }
         
        if (ucStat == 0) {
          
					n--;
            cX = GmcStack[n].cX;
            cY = GmcStack[n].cY;
            ucStep = GucMapStep[cX][cY];
        } else {
					  
            if (ucStat > 1) {                                            
                GmcStack[n].cX = cX;                                     
                GmcStack[n].cY = cY;                                     
                n++;
            }
             
            if ((GucMapBlock[cX][cY] & 0x01) &&                          
                (GucMapStep[cX][cY + 1] > (ucStep))) {                   
                cY++;                                                    
                continue;
            }
            if ((GucMapBlock[cX][cY] & 0x02) &&                          
                (GucMapStep[cX + 1][cY] > (ucStep))) {                   
                cX++;                                                    
                continue;
            }
            if ((GucMapBlock[cX][cY] & 0x04) &&                          
                (GucMapStep[cX][cY - 1] > (ucStep))) {                   
                cY--;                                                    
                continue;
            }
            if ((GucMapBlock[cX][cY] & 0x08) &&                          
                (GucMapStep[cX - 1][cY] > (ucStep))) {                   
                cX--;                                                    
                continue;
            }
        }
    }
}
void objectGoTo (char  cXdst, char  cYdst)
{		
    uchar ucStep = 1;
    char cNBlock = 0, cDirTemp;
    char cX,cY;
#ifdef MOUSE_REMOTE
    
    if (LP_AbortRequested()) return;
#endif
	ledon(4);ledon(5);
	ObjectGoTo_Flag=1;
    cX = GmcMouse.cX;
    cY = GmcMouse.cY;
    mapStepEdit(cXdst,cYdst);                                            
     
    while ((cX != cXdst) || (cY != cYdst))
	{
#ifdef MOUSE_REMOTE
        
        if (LP_AbortRequested()) { ObjectGoTo_Flag=0; return; }
#endif
        ucStep = GucMapStep[cX][cY];
         
        if ((GucMapBlock[cX][cY] & 0x01) &&                              
            (GucMapStep[cX][cY + 1] < ucStep)) {                         
            cDirTemp = UP;                                               
            if (cDirTemp == GucMouseDir) {                               
                cNBlock++;                                               
                cY++;
                continue;                                                
            }
        }
        if ((GucMapBlock[cX][cY] & 0x02) &&                              
            (GucMapStep[cX + 1][cY] < ucStep)) {                         
            cDirTemp = RIGHT;                                            
            if (cDirTemp == GucMouseDir) {                               
                cNBlock++;                                               
                cX++;
                continue;                                                
            }
        }
        if ((GucMapBlock[cX][cY] & 0x04) &&                              
            (GucMapStep[cX][cY - 1] < ucStep)) {                         
            cDirTemp = DOWN;                                             
            if (cDirTemp == GucMouseDir) {                               
                cNBlock++;                                               
                cY--;
                continue;                                                
            }
        }
        if ((GucMapBlock[cX][cY] & 0x08) &&                              
            (GucMapStep[cX - 1][cY] < ucStep)) {                         
            cDirTemp = LEFT;                                             
            if (cDirTemp == GucMouseDir) {                               
                cNBlock++;                                               
                cX--;
                continue;                                                
            }
        }
        cDirTemp = (cDirTemp + 4 - GucMouseDir)%4;                       
        
        if (cNBlock)
		{
			mouseGoahead(cNBlock);
        }        
        cNBlock = 0;                                                     
        
         
        switch (cDirTemp) {

        case 1:
            mouseTurnright();
            break;

        case 2:
            mouseTurnback();
            break;

        case 3:
            mouseTurnleft();
            break;

        default:
            break;
        }

    	cX = GmcMouse.cX;
    	cY = GmcMouse.cY;
    }
     
	
    if (cNBlock)
	{	
        mouseGoahead(cNBlock);
    }
	ObjectGoTo_Flag=0;
}

#define API __declspec(dllexport)
API void reset(int dir,int front,int side,int postwall,int right,int sample){
    memset(action_correct_sequence,0,sizeof(action_correct_sequence));
    memset(GucMapBlock,0,sizeof(GucMapBlock));
    parameter_search();speed_turn=30;speed=30;speedl=speedr=0;GucMouseTask=MAZESEARCH;disbf180=0;V6_TURN_CHAIN=0;host_straight_wall=0;
    GmcMouse.cX=GoalX=7;GmcMouse.cY=GoalY=7;GucMouseDir=dir;
    settrack(0);absolutetrack=basetrack=0;LastSearchAction=Stright;
    lefthaswall=lefthaswallh=(side&1)!=0;righthaswall=righthaswallh=(side&2)!=0;
    disl=dislh=dislhh=lefthaswall?40:200;disr=disrh=disrhh=righthaswall?40:200;
    forwardhaswall=front;front_plane=front?30:0;disf=disf1=disf2=front?30:300;
    post_left=right?postwall:0;post_right=right?0:postwall;post_sample=sample;
    e=eh=esum=gangle=0;turno=turnlefto=turnrighto=0;setvl=setvr=0;
    task=0;sleepmode=isemergency=0;accdistance=40;decdistance=10;afterturn_flag=0;
    tick=step=stoptick=turnaround_tick=0;sim_steps=0;block_write_flag=1;
    pivot_at=-1;pivot_count=0;departure_calls=0;departure_at=departure_end=-1;
    acc_calls=save_calls=point_calls=0;acc_end=save_at=-1;
    turn_count=coor_count=command_errors=0;ObjectGoTo_Flag=0;
}
API int route(u8 *map,int gx,int gy){
    int code=setjmp(escape);if(code)return code;memcpy(GucMapBlock,map,256);objectGoTo((char)gx,(char)gy);return 0;
}
API void frontdistance(int distance){front_plane=distance;disf=disf1=disf2=distance;}
API int back(int mode){
    int code=setjmp(escape);if(code)return code;
    if(mode==1){GoalX=0;GoalY=0;}
    if(mode==2){spurt_search_active=1;spurt_exec_index=200;speed_ss=speed_turn=70;turn_delay=10;}
    if(mode==3)specialmouseTurnback();else mouseTurnback();return 0;
}
API int ordinary(int right,int previous){
    int code=setjmp(escape);if(code)return code;LastSearchAction=previous;block_write_flag=0;
    if(right)mouseTurnright();else mouseTurnleft();return 0;
}
API int distance_case(int dis,int ramp){
    int code=setjmp(escape);if(code)return code;disbf180=(u16)dis;accdistance=(u16)ramp;settrack(0);
#ifdef HAS_GOAL_DEPARTURE
    goalDepartureAfterTurnback();
#endif
    return 0;
}
API int value(int i){switch(i){
case 0:return GmcMouse.cX;case 1:return GmcMouse.cY;case 2:return GucMouseDir;
case 3:return track;case 4:return LastSearchAction;case 5:return absolutetrack;
case 6:return pivot_at;case 7:return departure_calls;case 8:return departure_at;case 9:return departure_end;
case 10:return coor_count;case 11:return turn_count;case 12:return acc_calls;case 13:return save_calls;
case 14:return save_at;case 15:return afterturn_flag;case 16:return disbf180;case 17:return ObjectGoTo_Flag;
case 18:return point_calls;case 19:return command_errors;case 20:return pivot_count;case 21:return block_write_flag;case 22:return acc_end;
}return -999;}
API int turn(int i,int field){switch(field){case 0:return turn_codes[i];case 1:return turn_at[i];case 2:return entry_speed[i];case 3:return entry_previous[i];case 4:return entry_coor_count[i];}return -999;}
API int node(int i,int field){switch(field){case 0:return coor_x[i];case 1:return coor_y[i];case 2:return coor_dir[i];case 3:return coor_at[i];}return -999;}

API int profile(int i,int field){switch(field){case 0:return profile_slow[i];case 1:return profile_ticks[i];case 2:return profile_centre[i];case 3:return profile_start[i];case 4:return profile_end[i];case 5:return profile_outer_peak[i];}return -999;}
API void straight_wall(int enable){host_straight_wall=enable;}
API int series(u8 *actions,int count,int stage,int active){
    int i,code=setjmp(escape);if(code)return code;
    GucMouseTask=stage;spurt_search_active=(u8)active;
    if(active)spurt_exec_index=200;
    for(i=0;i<count;i++){
        if(actions[i]==0){
            if(host_straight_wall){lefthaswall=righthaswall=1;disl=disr=40;}
            mouseGoahead(1);
            if(host_straight_wall)exit_sensors();
        }
        else {
            if(actions[i]==1)mouseTurnleft();else mouseTurnright();
            mazeSearch();
        }
    }
    return 0;
}
