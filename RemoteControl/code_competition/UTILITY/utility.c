#include "timer.h"
#include "sys.h"
#include "usart.h"		
#include "delay.h"	
#include "adc.h"
#include "utility.h"
#include "stratagy.h"
#include "led.h"
#include "stmflash.h"
#include "user.h"
#ifdef MOUSE_REMOTE
#include "link_port.h" /* P2: 协作式中止查询 LP_AbortRequested() */
#endif

const short vouter_spurt[1]={0};
const short vinner_spurt[1]={0};
const short gyro_l_spurt[1]={0};
const short gyro_r_spurt[1]={0};


u8 turn_delay = 5;
u8 LastSearchAction=Stright;
int turnrighto,turnlefto;
int turno=0;
u8 spurt_45_end_flag=0;
extern u8 spurtTestFlag;
extern u8 ObjectGoTo_Flag;
extern u8 BackSearchFlag;
u8 spurt_action_num=0;
u8 afterturn_flag=0;
u8 goal_keep_flag=0;
u8 back90_flag=0;
extern u8 block_write_flag;
extern float SPURT90IR_kp1,SPURT90IR_kp2,SPURT90IR_kd,SPURT90GYRO_kp,SPURT90GYRO_kd;

extern uchar	Mapfastway[MAZETYPE][MAZETYPE]      ;

uchar actionsequence[200]={0}; 
uchar action_correct_sequence[200]={0}; 

extern char GoalX;
extern char GoalY;
extern u8 GoOrBackFlag;

extern uchar    GucXGoal0;             
extern uchar    GucXGoal1;
extern uchar    GucYGoal0;             
extern uchar    GucYGoal1;

extern MAZECOOR GmcMouse; 
extern  uchar    GucMouseTask;
extern u8 goaheadnum;
extern uchar	FastwayCount_90;
extern uchar	Mapfastway_90[MAZETYPE][MAZETYPE];
extern FASTWAYACTION	FastwayAction_90[MAZETYPE * MAZETYPE]; 


 
 
 
 #define  search_speed_70
 
 
 
 
 
 
 
 
#define LOW_90_ENABLE  
#define LOW_ENABLE	 
#define MEDIUM_ENABLE  
 

extern u8 blocknum;
extern u8 task,sleepmode;
extern u8 flashwrite;
extern u16 tick;
extern u8 step;
extern long e,eh,esum;
extern int speedl,speedr,speed;
extern long disf1,disf2,disf,disl,disr;
extern long dislh,disrh,dislhh,disrhh,disl45h,disr45h,disl45hh,disr45hh;
#ifndef MOUSE_REMOTE
extern u16 disl45,disr45;
#endif
extern long leftb,rightb,leftbh,rightbh,loopahead,absoluteangle,baseangle,angle;
extern long gangleh,ganglehh,peakgangle,peakgangleh;
extern long leftd,rightd,leftdh,rightdh,leftcycle,rightcycle,absolutetrack,absolutetrackl,absolutetrackr,basetrack,basetrackl,basetrackr,trackl,trackr,track;
#ifndef MOUSE_REMOTE
extern int setvl,setvr;
#endif
 
extern int ganglet,gangle;
 
extern u16 speed_ss,speed_turn,speed_fastss;
extern u8 lefthaswall,righthaswall,forwardhaswall,lefthaswallh,righthaswallh,lefthaswall45,righthaswall45,lefthaswallh45,righthaswallh45,leftwallcriticalhhh,rightwallcriticalhhh;;
extern u8 leftwallcritical,rightwallcritical,leftwallcriticalh,rightwallcriticalh,leftwallcriticalhh,rightwallcriticalhh;
extern u8 irswitch;
extern u16 turnaround_tick;
extern u16 flashaddr,flashaddrmax;
extern u8 sidewall_threshold;

extern MAZECOOR GmcMouse;                                                
                                                                         
                                                                        
extern uchar    GucMouseDir;                                             
extern uchar    GucMapBlock[MAZETYPE][MAZETYPE];                         
                                                                         
                                                                        
                                                                        
extern uchar	GucMapGet[MAZETYPE][MAZETYPE];

 
extern FASTWAYACTION FastwayAction[MAZETYPE * MAZETYPE];               
extern uchar	FastwayCount;

extern const short *turn_gyro,*turn_vl,*turn_vr; 
extern u16 dislpeak,disrpeak;
u8 lpeakfindenable,rpeakfindenable;
extern u16 leftpeaktrack,rightpeaktrack;
u8 goaheadbugflag=0;
extern u8 EMERGENCYON;
extern u16 isemergency;
u8 speedmode;
extern u8 kalmanswitch;

extern u16 speed_ss;
extern u16 speed_turn;
extern u16 speed_fastss;	
extern double GOSTRAIGHT_kp;
extern double SMARTSTRAIGHTFAST_bigerror_kp;
extern double SMARTSTRAIGHTFAST_smallerror_kp;
extern double STRAIGHT45_kp,STRAIGHT45_kd;
extern double turn_kp,turn_kd;
 
 
extern int stoptick;
 

 
 
 
 
 

 

 

 

 

 

 

 

 


	
	
#ifdef search_speed_30
 
 
 
 
 
 
 
 
 
 
 
 
 
 
 
#endif	
	 
 
#ifdef search_speed_50
const short gyro_l_search[222]={90,90,90,90,90,90,90,90,90,90,89,89,89,89,89,89,89,89,88,88,88,88,88,87,87,87,87,87,86,86,86,85,85,85,85,84,84,84,83,83,83,82,82,81,81,81,80,80,79,79,79,78,78,77,77,76,76,75,75,74,74,73,73,72,72,71,71,70,70,69,68,68,67,67,66,66,65,65,64,64,63,62,62,61,61,60,60,59,58,58,57,57,56,56,55,54,54,53,53,52,51,51,50,50,49,48,48,47,46,46,45,44,44,43,43,42,41,41,40,39,39,38,38,37,36,36,35,35,34,33,33,32,32,31,31,30,29,29,28,28,27,27,26,25,25,24,24,23,23,22,22,21,21,20,20,19,18,18,17,17,16,16,15,15,14,14,13,13,12,12,11,11,10,10,10,9,9,8,8,8,7,7,6,6,6,5,5,5,4,4,4,4,3,3,3,3,2,2,2,2,2,1,1,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_r_search[222]={-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-89,-89,-89,-89,-89,-89,-89,-89,-88,-88,-88,-88,-88,-87,-87,-87,-87,-87,-86,-86,-86,-85,-85,-85,-85,-84,-84,-84,-83,-83,-83,-82,-82,-81,-81,-81,-80,-80,-79,-79,-79,-78,-78,-77,-77,-76,-76,-75,-75,-74,-74,-73,-73,-72,-72,-71,-71,-70,-70,-69,-68,-68,-67,-67,-66,-66,-65,-65,-64,-64,-63,-62,-62,-61,-61,-60,-60,-59,-58,-58,-57,-57,-56,-56,-55,-54,-54,-53,-53,-52,-51,-51,-50,-50,-49,-48,-48,-47,-46,-46,-45,-44,-44,-43,-43,-42,-41,-41,-40,-39,-39,-38,-38,-37,-36,-36,-35,-35,-34,-33,-33,-32,-32,-31,-31,-30,-29,-29,-28,-28,-27,-27,-26,-25,-25,-24,-24,-23,-23,-22,-22,-21,-21,-20,-20,-19,-18,-18,-17,-17,-16,-16,-15,-15,-14,-14,-13,-13,-12,-12,-11,-11,-10,-10,-10,-9,-9,-8,-8,-8,-7,-7,-6,-6,-6,-5,-5,-5,-4,-4,-4,-4,-3,-3,-3,-3,-2,-2,-2,-2,-2,-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_search[222]={51,51,52,52,53,53,54,54,55,55,56,56,57,58,58,59,59,60,60,61,61,62,62,63,63,64,65,65,66,66,67,67,68,68,69,69,70,70,71,72,72,73,73,74,74,75,75,76,76,77,78,78,79,79,80,80,80,80,81,81,81,81,81,81,81,82,82,82,82,82,82,83,83,83,83,83,83,84,84,84,84,84,84,85,85,85,85,85,85,86,86,86,86,86,86,86,87,87,87,87,87,87,88,88,88,88,88,88,89,89,89,89,89,88,88,88,88,88,88,88,87,87,87,87,87,87,86,86,86,86,86,86,86,85,85,85,85,85,85,84,84,84,84,84,84,84,83,83,83,83,83,83,82,82,82,82,82,82,82,81,81,81,81,81,81,80,80,80,80,80,79,78,78,77,77,76,75,75,74,74,73,72,72,71,71,70,69,69,68,68,67,66,66,65,65,64,63,63,62,61,61,60,60,59,58,58,57,57,56,55,55,54,54,53,52,52,51,51,50,50,50,50};
const short vinner_search[222]={49,49,48,48,47,47,46,46,45,45,44,44,43,42,42,41,41,40,40,39,39,38,38,37,37,36,35,35,34,34,33,33,32,32,31,31,30,30,29,28,28,27,27,26,26,25,25,24,24,23,22,22,21,21,20,20,20,20,19,19,19,19,19,19,19,18,18,18,18,18,18,17,17,17,17,17,17,16,16,16,16,16,16,15,15,15,15,15,15,14,14,14,14,14,14,14,13,13,13,13,13,13,12,12,12,12,12,12,11,11,11,11,11,12,12,12,12,12,12,12,13,13,13,13,13,13,14,14,14,14,14,14,14,15,15,15,15,15,15,16,16,16,16,16,16,16,17,17,17,17,17,17,18,18,18,18,18,18,18,19,19,19,19,19,19,20,20,20,20,20,21,22,22,23,23,24,25,25,26,26,27,28,28,29,29,30,31,31,32,32,33,34,34,35,35,36,37,37,38,39,39,40,40,41,42,42,43,43,44,45,45,46,46,47,48,48,49,49,50,50,50,50};	
#endif

 
#ifdef search_speed_70
 
 
 
 
 
 
 
 
 
 

#endif

	
	 
 
 
 
 
 
 
	
	
 

 

 
 


 

 

 

	
 
 
 
 
 
 
 
 
	
#ifdef LOW_ENABLE
	
 
 
 
 
 
/*
const short vouter_t90_low[341]={40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 59, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 48, 47, 46, 45, 44, 43, 42, 41, 40};
const short vinner_t90_low[341]={40, 39, 38, 37, 36, 35, 34, 33, 32, 31, 30, 29, 28, 27, 26, 25, 24, 23, 22, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40};
const short gyro_lt90_low[341]={90, 90, 89, 89, 89, 89, 88, 88, 88, 88, 87, 87, 87, 86, 86, 86, 86, 85, 85, 85, 85, 84, 84, 84, 83, 83, 83, 83, 82, 82, 82, 82, 81, 81, 81, 80, 80, 80, 80, 79, 79, 79, 79, 78, 78, 78, 77, 77, 77, 77, 76, 76, 76, 76, 75, 75, 75, 74, 74, 74, 74, 73, 73, 73, 73, 72, 72, 72, 71, 71, 71, 71, 70, 70, 70, 70, 69, 69, 69, 68, 68, 68, 68, 67, 67, 67, 67, 66, 66, 66, 65, 65, 65, 65, 64, 64, 64, 64, 63, 63, 63, 62, 62, 62, 62, 61, 61, 61, 61, 60, 60, 60, 59, 59, 59, 59, 58, 58, 58, 58, 57, 57, 57, 56, 56, 56, 56, 55, 55, 55, 55, 54, 54, 54, 53, 53, 53, 53, 52, 52, 52, 52, 51, 51, 51, 50, 50, 50, 50, 49, 49, 49, 49, 48, 48, 48, 47, 47, 47, 47, 46, 46, 46, 46, 45, 45, 45, 44, 44, 44, 44, 43, 43, 43, 43, 42, 42, 42, 41, 41, 41, 41, 40, 40, 40, 40, 39, 39, 39, 38, 38, 38, 38, 37, 37, 37, 37, 36, 36, 36, 35, 35, 35, 35, 34, 34, 34, 34, 33, 33, 33, 32, 32, 32, 32, 31, 31, 31, 31, 30, 30, 30, 29, 29, 29, 29, 28, 28, 28, 28, 27, 27, 27, 26, 26, 26, 26, 25, 25, 25, 25, 24, 24, 24, 23, 23, 23, 23, 22, 22, 22, 22, 21, 21, 21, 20, 20, 20, 20, 19, 19, 19, 19, 18, 18, 18, 17, 17, 17, 17, 16, 16, 16, 16, 15, 15, 15, 14, 14, 14, 14, 13, 13, 13, 13, 12, 12, 12, 11, 11, 11, 11, 10, 10, 10, 10, 9, 9, 9, 8, 8, 8, 8, 7, 7, 7, 7, 6, 6, 6, 5, 5, 5, 5, 4, 4, 4, 4, 3, 3, 3, 2, 2, 2, 2, 1, 1, 1, 1, 0, 0, 0, -1, -1, -1, -1, -2, -2, -2, -2, -3};
const short gyro_rt90_low[341]={-90, -90, -89, -89, -89, -89, -88, -88, -88, -88, -87, -87, -87, -86, -86, -86, -86, -85, -85, -85, -85, -84, -84, -84, -83, -83, -83, -83, -82, -82, -82, -82, -81, -81, -81, -80, -80, -80, -80, -79, -79, -79, -79, -78, -78, -78, -77, -77, -77, -77, -76, -76, -76, -76, -75, -75, -75, -74, -74, -74, -74, -73, -73, -73, -73, -72, -72, -72, -71, -71, -71, -71, -70, -70, -70, -70, -69, -69, -69, -68, -68, -68, -68, -67, -67, -67, -67, -66, -66, -66, -65, -65, -65, -65, -64, -64, -64, -64, -63, -63, -63, -62, -62, -62, -62, -61, -61, -61, -61, -60, -60, -60, -59, -59, -59, -59, -58, -58, -58, -58, -57, -57, -57, -56, -56, -56, -56, -55, -55, -55, -55, -54, -54, -54, -53, -53, -53, -53, -52, -52, -52, -52, -51, -51, -51, -50, -50, -50, -50, -49, -49, -49, -49, -48, -48, -48, -47, -47, -47, -47, -46, -46, -46, -46, -45, -45, -45, -44, -44, -44, -44, -43, -43, -43, -43, -42, -42, -42, -41, -41, -41, -41, -40, -40, -40, -40, -39, -39, -39, -38, -38, -38, -38, -37, -37, -37, -37, -36, -36, -36, -35, -35, -35, -35, -34, -34, -34, -34, -33, -33, -33, -32, -32, -32, -32, -31, -31, -31, -31, -30, -30, -30, -29, -29, -29, -29, -28, -28, -28, -28, -27, -27, -27, -26, -26, -26, -26, -25, -25, -25, -25, -24, -24, -24, -23, -23, -23, -23, -22, -22, -22, -22, -21, -21, -21, -20, -20, -20, -20, -19, -19, -19, -19, -18, -18, -18, -17, -17, -17, -17, -16, -16, -16, -16, -15, -15, -15, -14, -14, -14, -14, -13, -13, -13, -13, -12, -12, -12, -11, -11, -11, -11, -10, -10, -10, -10, -9, -9, -9, -8, -8, -8, -8, -7, -7, -7, -7, -6, -6, -6, -5, -5, -5, -5, -4, -4, -4, -4, -3, -3, -3, -2, -2, -2, -2, -1, -1, -1, -1, 0, 0, 0, 1, 1, 1, 1, 2, 2, 2, 2, 3};
*/
	
 


 const short vouter_t90_low[195]={70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 101, 102, 103, 104, 105, 106, 107, 108, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 109, 108, 107, 106, 105, 104, 103, 102, 101, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 90, 89, 88, 87, 86, 85, 84, 83, 82, 81, 80, 79, 78, 77, 76, 75, 74, 73, 72, 71, 70};
const short vinner_t90_low[195]={70, 69, 68, 67, 66, 65, 64, 63, 62, 61, 60, 59, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 48, 47, 46, 45, 44, 43, 42, 41, 40, 39, 38, 37, 36, 35, 34, 33, 32, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70};
const short gyro_lt90_low[195]={90, 90, 89, 89, 88, 88, 87, 87, 86, 86, 85, 85, 84, 84, 83, 83, 82, 82, 81, 81, 80, 80, 79, 79, 79, 78, 78, 77, 77, 76, 76, 75, 75, 74, 74, 73, 73, 72, 72, 71, 71, 70, 70, 69, 69, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 64, 63, 63, 62, 62, 61, 61, 60, 60, 59, 59, 58, 58, 58, 57, 57, 56, 56, 55, 55, 54, 54, 53, 53, 52, 52, 51, 51, 50, 50, 49, 49, 48, 48, 48, 47, 47, 46, 46, 45, 45, 44, 44, 43, 43, 42, 42, 41, 41, 40, 40, 39, 39, 38, 38, 37, 37, 37, 36, 36, 35, 35, 34, 34, 33, 33, 32, 32, 31, 31, 30, 30, 29, 29, 28, 28, 27, 27, 26, 26, 26, 25, 25, 24, 24, 23, 23, 22, 22, 21, 21, 20, 20, 19, 19, 18, 18, 17, 17, 16, 16, 16, 15, 15, 14, 14, 13, 13, 12, 12, 11, 11, 10, 10, 9, 9, 8, 8, 7, 7, 6, 6, 5, 5, 5, 4, 4, 3, 3, 2, 2, 1, 1, 0, 0, -1, -1, -2, -2, -3};
const short gyro_rt90_low[195]={-90, -90, -89, -89, -88, -88, -87, -87, -86, -86, -85, -85, -84, -84, -83, -83, -82, -82, -81, -81, -80, -80, -79, -79, -79, -78, -78, -77, -77, -76, -76, -75, -75, -74, -74, -73, -73, -72, -72, -71, -71, -70, -70, -69, -69, -69, -68, -68, -67, -67, -66, -66, -65, -65, -64, -64, -63, -63, -62, -62, -61, -61, -60, -60, -59, -59, -58, -58, -58, -57, -57, -56, -56, -55, -55, -54, -54, -53, -53, -52, -52, -51, -51, -50, -50, -49, -49, -48, -48, -48, -47, -47, -46, -46, -45, -45, -44, -44, -43, -43, -42, -42, -41, -41, -40, -40, -39, -39, -38, -38, -37, -37, -37, -36, -36, -35, -35, -34, -34, -33, -33, -32, -32, -31, -31, -30, -30, -29, -29, -28, -28, -27, -27, -26, -26, -26, -25, -25, -24, -24, -23, -23, -22, -22, -21, -21, -20, -20, -19, -19, -18, -18, -17, -17, -16, -16, -16, -15, -15, -14, -14, -13, -13, -12, -12, -11, -11, -10, -10, -9, -9, -8, -8, -7, -7, -6, -6, -5, -5, -5, -4, -4, -3, -3, -2, -2, -1, -1, 0, 0, 1, 1, 2, 2, 3};

	
//90v度V转弯，出入点x,y坐标距离分界线都是20mm，斜线距离28mm xbase=11 ybase=20-666
const short gyro_lv90_low[187]={90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,90,89,89,89,89,89,89,89,88,88,88,88,88,87,87,87,87,86,86,86,85,85,85,84,84,84,83,83,83,82,82,81,81,81,80,80,79,79,78,78,77,77,76,75,75,74,74,73,73,72,71,71,70,69,69,68,67,67,66,65,64,64,63,62,61,61,60,59,58,57,56,56,55,54,53,52,51,50,49,48,47,46,46,45,44,43,42,41,40,39,38,37,36,35,34,33,32,32,31,30,29,28,27,26,25,24,23,22,21,20,19,19,18,17,16,15,14,14,13,12,11,10,10,9,8,7,7,6,5,5,4,4,3,3,2,2,2,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rv90_low[187]={-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-90,-89,-89,-89,-89,-89,-89,-89,-88,-88,-88,-88,-88,-87,-87,-87,-87,-86,-86,-86,-85,-85,-85,-84,-84,-84,-83,-83,-83,-82,-82,-81,-81,-81,-80,-80,-79,-79,-78,-78,-77,-77,-76,-75,-75,-74,-74,-73,-73,-72,-71,-71,-70,-69,-69,-68,-67,-67,-66,-65,-64,-64,-63,-62,-61,-61,-60,-59,-58,-57,-56,-56,-55,-54,-53,-52,-51,-50,-49,-48,-47,-46,-46,-45,-44,-43,-42,-41,-40,-39,-38,-37,-36,-35,-34,-33,-32,-32,-31,-30,-29,-28,-27,-26,-25,-24,-23,-22,-21,-20,-19,-19,-18,-17,-16,-15,-14,-14,-13,-12,-11,-10,-10,-9,-8,-7,-7,-6,-5,-5,-4,-4,-3,-3,-2,-2,-2,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_v90_low[187]={100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,100,100,100,101,101,102,102,103,103,104,104,105,105,106,106,107,107,108,108,109,109,110,110,111,111,112,112,113,113,114,115,116,116,117,118,119,120,121,121,122,123,124,125,126,126,127,128,129,130,131,131,132,133,134,135,136,136,137,137,138,138,138,139,139,139,139,140,140,140,141,141,141,142,142,142,142,143,143,143,144,144,144,144,145,145,145,145,145,145,144,144,143,143,142,142,141,141,141,140,140,139,139,138,138,137,137,135,133,131,129,127,126,124,122,120,118,116,114,112,110,108,106,104,102,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_v90_low[187]={100,99,97,96,95,93,92,91,89,88,87,85,84,82,81,80,78,77,76,74,73,72,70,69,68,66,65,64,62,61,60,59,58,58,57,56,55,54,53,53,52,51,50,49,48,48,47,46,45,44,44,43,42,41,40,39,39,38,37,36,36,35,35,34,34,34,33,33,32,32,31,31,30,30,29,29,28,28,27,27,26,26,25,25,24,24,23,23,23,24,24,24,25,25,25,25,26,26,26,27,27,27,27,28,28,28,29,29,29,30,30,30,30,31,31,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,52,54,57,59,62,64,67,69,72,74,77,79,82,84,87,89,92,94,97,99,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};

 
 
 const short gyro_lt45_low[152]={45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,44,44,44,44,43,43,43,42,42,41,41,41,40,39,39,38,38,37,36,36,35,34,34,33,32,32,31,30,29,29,28,27,27,26,25,25,24,23,23,22,21,21,20,19,19,18,17,17,16,16,15,15,14,14,13,13,12,12,11,11,10,10,9,9,8,8,8,7,7,6,6,6,5,5,5,4,4,4,4,3,3,3,3,2,2,2,2,2,1,1,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rt45_low[152]={-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-44,-44,-44,-44,-43,-43,-43,-42,-42,-41,-41,-41,-40,-39,-39,-38,-38,-37,-36,-36,-35,-34,-34,-33,-32,-32,-31,-30,-29,-29,-28,-27,-27,-26,-25,-25,-24,-23,-23,-22,-21,-21,-20,-19,-19,-18,-17,-17,-16,-16,-15,-15,-14,-14,-13,-13,-12,-12,-11,-11,-10,-10,-9,-9,-8,-8,-8,-7,-7,-6,-6,-6,-5,-5,-5,-4,-4,-4,-4,-3,-3,-3,-3,-2,-2,-2,-2,-2,-1,-1,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_t45_low[152]={100,100,100,101,101,101,101,102,102,102,102,103,103,104,105,107,108,109,111,112,114,115,117,118,119,121,121,121,121,121,121,122,122,122,122,122,122,122,122,123,123,123,123,123,123,122,122,121,121,120,120,119,119,118,118,117,117,116,115,115,114,114,113,113,112,112,112,112,111,111,111,111,110,110,110,110,109,109,109,109,108,108,108,107,107,107,107,106,106,106,106,105,105,105,105,104,104,104,104,103,103,103,103,102,102,102,101,101,101,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_t45_low[152]={100,97,93,90,86,83,79,76,72,69,66,62,59,56,54,51,49,47,45,42,40,38,36,34,31,29,29,30,30,30,30,30,30,30,30,31,31,31,31,31,31,31,31,32,32,33,34,34,35,36,37,38,38,39,40,41,42,42,43,44,45,46,46,47,48,49,50,52,53,54,55,56,57,58,59,60,61,62,63,65,66,67,68,69,70,71,72,73,74,75,76,78,79,80,81,82,83,84,85,86,87,88,89,91,92,93,94,95,96,97,98,99,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};

//45v度由斜转正，入点x,y坐标都是20mm，斜线距离28mm  xbase=11 ybase=20-666
const short gyro_lv45_low[171]={45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,45,44,44,44,44,44,44,43,43,43,43,42,42,42,42,41,41,41,40,40,39,39,39,38,38,37,37,36,36,35,35,34,33,33,32,32,31,30,30,29,28,27,27,26,25,24,24,23,22,21,20,19,18,18,17,16,15,14,13,12,11,11,10,9,8,7,6,5,5,4,3,3,2,2,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rv45_low[171]={-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-45,-44,-44,-44,-44,-44,-44,-43,-43,-43,-43,-42,-42,-42,-42,-41,-41,-41,-40,-40,-39,-39,-39,-38,-38,-37,-37,-36,-36,-35,-35,-34,-33,-33,-32,-32,-31,-30,-30,-29,-28,-27,-27,-26,-25,-24,-24,-23,-22,-21,-20,-19,-18,-18,-17,-16,-15,-14,-13,-12,-11,-11,-10,-9,-8,-7,-6,-5,-5,-4,-3,-3,-2,-2,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_v45_low[171]={100,100,100,99,99,99,99,99,99,98,98,98,98,98,97,97,97,97,97,97,96,96,96,96,96,95,95,95,95,95,95,94,94,94,94,94,94,93,93,93,93,93,92,92,92,92,92,92,91,91,91,91,91,91,91,92,93,94,94,95,96,97,98,98,99,100,101,101,102,103,104,105,105,106,107,108,108,109,110,111,111,112,113,114,115,115,116,117,118,118,119,120,121,121,122,123,124,125,125,126,127,128,128,129,130,131,132,132,133,134,135,135,136,136,136,137,137,137,138,138,138,139,139,139,140,140,139,136,134,131,128,126,123,120,117,115,112,109,107,104,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_v45_low[171]={100,100,100,99,99,99,99,99,99,98,98,98,98,98,97,97,97,97,97,97,96,96,96,96,96,95,95,95,95,95,95,94,94,94,94,94,94,93,93,93,93,93,92,92,92,92,92,92,91,91,91,91,91,90,89,88,87,86,85,83,82,81,80,79,78,77,76,74,73,72,71,70,69,68,66,65,64,63,62,61,60,59,57,56,55,54,53,52,51,49,48,47,46,45,44,43,42,40,39,38,37,36,35,34,33,31,30,29,28,27,26,25,25,25,26,26,27,27,27,28,28,28,29,29,29,30,32,37,41,46,51,55,60,65,70,74,79,84,88,93,98,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};

//135t度有正转斜，出入点距离柱子中间距离30mm	 xbase=9 ybase=15-666
const short gyro_lt135_low[302]={135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,134,134,134,134,134,134,134,134,134,134,133,133,133,133,133,133,132,132,132,132,132,131,131,131,131,131,130,130,130,130,129,129,129,128,128,128,128,127,127,127,126,126,126,125,125,125,124,124,124,123,123,122,122,122,121,121,120,120,119,119,119,118,118,117,117,116,116,115,115,114,114,113,113,112,112,111,111,110,109,109,108,108,107,107,106,105,105,104,104,103,102,102,101,100,100,99,98,98,97,96,96,95,94,94,93,92,91,91,90,89,88,88,87,86,85,85,84,83,82,81,81,80,79,78,77,76,75,75,74,73,72,71,70,69,69,68,67,66,65,64,63,63,62,61,60,59,58,57,56,56,55,54,53,52,51,50,50,49,48,47,46,45,44,43,43,42,41,40,39,38,37,37,36,35,34,33,32,31,31,30,29,28,27,26,26,25,24,23,22,22,21,20,19,19,18,17,17,16,15,14,14,13,12,12,11,10,10,9,9,8,7,7,6,6,5,5,4,4,4,3,3,3,2,2,2,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rt135_low[302]={-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-134,-134,-134,-134,-134,-134,-134,-134,-134,-134,-133,-133,-133,-133,-133,-133,-132,-132,-132,-132,-132,-131,-131,-131,-131,-131,-130,-130,-130,-130,-129,-129,-129,-128,-128,-128,-128,-127,-127,-127,-126,-126,-126,-125,-125,-125,-124,-124,-124,-123,-123,-122,-122,-122,-121,-121,-120,-120,-119,-119,-119,-118,-118,-117,-117,-116,-116,-115,-115,-114,-114,-113,-113,-112,-112,-111,-111,-110,-109,-109,-108,-108,-107,-107,-106,-105,-105,-104,-104,-103,-102,-102,-101,-100,-100,-99,-98,-98,-97,-96,-96,-95,-94,-94,-93,-92,-91,-91,-90,-89,-88,-88,-87,-86,-85,-85,-84,-83,-82,-81,-81,-80,-79,-78,-77,-76,-75,-75,-74,-73,-72,-71,-70,-69,-69,-68,-67,-66,-65,-64,-63,-63,-62,-61,-60,-59,-58,-57,-56,-56,-55,-54,-53,-52,-51,-50,-50,-49,-48,-47,-46,-45,-44,-43,-43,-42,-41,-40,-39,-38,-37,-37,-36,-35,-34,-33,-32,-31,-31,-30,-29,-28,-27,-26,-26,-25,-24,-23,-22,-22,-21,-20,-19,-19,-18,-17,-17,-16,-15,-14,-14,-13,-12,-12,-11,-10,-10,-9,-9,-8,-7,-7,-6,-6,-5,-5,-4,-4,-4,-3,-3,-3,-2,-2,-2,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_t135_low[302]={100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,100,100,100,100,101,101,101,102,102,102,103,103,103,103,104,104,104,105,105,105,106,106,106,106,107,107,107,108,108,108,108,109,109,109,110,110,110,111,111,111,111,112,112,112,113,113,113,114,114,115,115,116,116,117,117,118,118,119,119,120,120,121,121,122,122,123,123,124,124,125,125,126,126,127,127,128,129,129,130,130,131,131,132,132,133,133,134,134,135,135,136,136,136,136,137,137,137,137,137,137,138,138,138,138,138,139,139,139,139,139,139,140,140,140,140,140,141,141,141,141,141,141,142,142,142,142,142,143,143,143,143,143,143,144,144,144,144,144,144,144,144,143,143,143,143,142,142,142,142,141,141,141,141,140,140,140,139,139,139,139,138,138,138,138,137,137,137,137,136,136,134,133,132,131,130,129,127,126,125,124,123,122,120,119,118,117,116,115,114,112,111,110,109,108,107,105,104,103,102,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_t135_low[302]={100,99,98,98,97,96,95,94,93,93,92,91,90,89,88,88,87,86,85,84,83,83,82,81,80,79,79,78,77,76,75,74,74,73,72,71,70,69,69,68,67,66,65,65,64,63,62,61,61,60,60,59,59,58,58,57,57,56,56,55,55,54,54,53,53,52,52,51,51,50,50,49,49,48,48,47,47,46,46,45,45,44,44,43,43,42,42,41,41,40,40,39,39,38,38,37,37,37,36,36,36,35,35,35,35,34,34,34,33,33,33,33,32,32,32,31,31,31,31,30,30,30,29,29,29,29,28,28,28,27,27,27,27,26,26,26,25,25,25,25,24,24,24,25,25,25,25,25,26,26,26,26,26,26,27,27,27,27,27,28,28,28,28,28,28,29,29,29,29,29,30,30,30,30,30,30,31,31,31,31,31,32,32,32,32,32,32,33,33,34,34,35,36,36,37,38,38,39,39,40,41,41,42,43,43,44,45,45,46,46,47,48,48,49,50,50,51,51,52,53,55,56,58,59,61,62,64,65,67,68,70,72,73,75,76,78,79,81,82,84,85,87,88,90,91,93,94,96,97,99,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};

//135v度由斜转正，入点x,y坐标都是20mm，斜线距离28mm	xbase=11 ybase=20-666
const short gyro_lv135_low[294]={135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,135,134,134,134,134,134,134,134,134,134,134,134,133,133,133,133,133,133,133,132,132,132,132,132,131,131,131,131,131,130,130,130,130,130,129,129,129,129,128,128,128,128,127,127,127,126,126,126,125,125,125,124,124,124,123,123,123,122,122,122,121,121,121,120,120,119,119,119,118,118,117,117,116,116,116,115,115,114,114,113,113,112,112,111,111,110,110,109,109,108,108,107,107,106,106,105,104,104,103,103,102,102,101,100,100,99,99,98,97,97,96,96,95,94,94,93,92,92,91,90,90,89,88,87,87,86,85,85,84,83,82,82,81,80,79,79,78,77,76,76,75,74,73,73,72,71,70,69,69,68,67,66,65,65,64,63,62,61,61,60,59,58,57,57,56,55,54,54,53,52,51,50,50,49,48,47,46,46,45,44,43,42,42,41,40,39,39,38,37,36,35,35,34,33,32,31,31,30,29,28,28,27,26,25,25,24,23,23,22,21,20,20,19,18,18,17,16,16,15,15,14,13,13,12,11,11,10,10,9,9,8,7,7,7,6,6,5,5,4,4,4,3,3,3,2,2,2,2,1,1,1,1,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short gyro_rv135_low[294]={-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-135,-134,-134,-134,-134,-134,-134,-134,-134,-134,-134,-134,-133,-133,-133,-133,-133,-133,-133,-132,-132,-132,-132,-132,-131,-131,-131,-131,-131,-130,-130,-130,-130,-130,-129,-129,-129,-129,-128,-128,-128,-128,-127,-127,-127,-126,-126,-126,-125,-125,-125,-124,-124,-124,-123,-123,-123,-122,-122,-122,-121,-121,-121,-120,-120,-119,-119,-119,-118,-118,-117,-117,-116,-116,-116,-115,-115,-114,-114,-113,-113,-112,-112,-111,-111,-110,-110,-109,-109,-108,-108,-107,-107,-106,-106,-105,-104,-104,-103,-103,-102,-102,-101,-100,-100,-99,-99,-98,-97,-97,-96,-96,-95,-94,-94,-93,-92,-92,-91,-90,-90,-89,-88,-87,-87,-86,-85,-85,-84,-83,-82,-82,-81,-80,-79,-79,-78,-77,-76,-76,-75,-74,-73,-73,-72,-71,-70,-69,-69,-68,-67,-66,-65,-65,-64,-63,-62,-61,-61,-60,-59,-58,-57,-57,-56,-55,-54,-54,-53,-52,-51,-50,-50,-49,-48,-47,-46,-46,-45,-44,-43,-42,-42,-41,-40,-39,-39,-38,-37,-36,-35,-35,-34,-33,-32,-31,-31,-30,-29,-28,-28,-27,-26,-25,-25,-24,-23,-23,-22,-21,-20,-20,-19,-18,-18,-17,-16,-16,-15,-15,-14,-13,-13,-12,-11,-11,-10,-10,-9,-9,-8,-7,-7,-7,-6,-6,-5,-5,-4,-4,-4,-3,-3,-3,-2,-2,-2,-2,-1,-1,-1,-1,-1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0};
const short vouter_v135_low[294]={100,100,100,100,100,100,100,100,100,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,99,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,98,97,97,97,97,97,97,97,97,97,97,97,98,98,98,98,99,99,99,99,100,100,100,100,100,101,101,101,101,102,102,102,102,103,103,103,103,104,104,104,104,104,105,105,105,105,106,106,106,106,107,107,107,107,107,108,108,108,108,109,109,109,110,110,111,111,111,112,112,113,113,114,114,114,115,115,116,116,117,117,117,118,118,119,119,120,120,120,121,121,122,122,123,123,123,124,124,125,125,126,126,126,127,127,128,128,129,129,129,130,130,131,131,131,131,132,132,132,132,132,132,133,133,133,133,133,133,134,134,134,134,134,134,135,135,135,135,135,135,136,136,136,136,136,136,137,137,137,137,137,137,138,138,138,138,138,138,139,139,139,139,139,139,140,139,139,139,139,139,138,138,138,138,138,137,137,137,137,137,136,136,136,136,135,135,135,135,135,134,134,134,134,134,133,133,133,133,133,132,131,130,129,128,127,126,125,124,123,122,121,120,119,118,118,117,116,115,114,113,112,111,110,109,108,107,106,105,104,103,102,101,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};
const short vinner_v135_low[294]={100,99,99,98,97,96,96,95,94,94,93,92,91,91,90,89,88,88,87,86,86,85,84,83,83,82,81,81,80,79,78,78,77,76,75,75,74,73,73,72,71,70,70,69,68,68,67,66,65,65,64,63,63,62,62,61,61,61,60,60,59,59,58,58,58,57,57,56,56,55,55,55,54,54,53,53,52,52,52,51,51,50,50,49,49,49,48,48,47,47,46,46,46,45,45,44,44,43,43,42,42,42,41,41,41,40,40,40,40,39,39,39,39,39,38,38,38,38,37,37,37,37,36,36,36,36,35,35,35,35,35,34,34,34,34,33,33,33,33,32,32,32,32,32,31,31,31,31,30,30,30,30,29,29,29,29,29,30,30,30,30,30,30,31,31,31,31,31,31,32,32,32,32,32,32,33,33,33,33,33,33,34,34,34,34,34,34,35,35,35,35,35,35,36,36,36,36,36,36,37,37,37,37,37,37,38,38,39,39,40,40,41,41,42,42,43,43,44,45,45,46,46,47,47,48,48,49,49,50,50,51,52,52,53,53,54,54,55,55,56,57,58,60,61,62,63,65,66,67,69,70,71,72,74,75,76,78,79,80,81,83,84,85,87,88,89,90,92,93,94,96,97,98,99,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100,100};

/*
 

const short gyro_lt45_low[1]={0};
const short gyro_rt45_low[1]={0};
const short vouter_t45_low[1]={0};
const short vinner_t45_low[1]={0};

 
 
 
 

 

const short gyro_lv45_low[1]={0};
const short gyro_rv45_low[1]={0};
const short vouter_v45_low[1]={0};
const short vinner_v45_low[1]={0};

 
 
 
 

 

const short gyro_lt135_low[1]={0};
const short gyro_rt135_low[1]={0};
const short vouter_t135_low[1]={0};
const short vinner_t135_low[1]={0};

 
 
 
 

 

const short gyro_lv135_low[1]={0};
const short gyro_rv135_low[1]={0};
const short vouter_v135_low[1]={0};
const short vinner_v135_low[1]={0};

 */
 
 
 

 
const short vouter_180_low[391]={70, 71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 101, 102, 103, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 104, 103, 102, 101, 100, 99, 98, 97, 96, 95, 94, 93, 92, 91, 90, 89, 88, 87, 86, 85, 84, 83, 82, 81, 80, 79, 78, 77, 76, 75, 74, 73, 72, 71, 70};
const short vinner_180_low[391]={70, 69, 68, 67, 66, 65, 64, 63, 62, 61, 60, 59, 58, 57, 56, 55, 54, 53, 52, 51, 50, 49, 48, 47, 46, 45, 44, 43, 42, 41, 40, 39, 38, 37, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 67, 68, 69, 70};
const short gyro_l180_low[391]={180, 180, 179, 179, 178, 178, 177, 177, 176, 176, 175, 175, 174, 174, 173, 173, 172, 172, 171, 171, 170, 170, 169, 169, 169, 168, 168, 167, 167, 166, 166, 165, 165, 164, 164, 163, 163, 162, 162, 161, 161, 160, 160, 159, 159, 159, 158, 158, 157, 157, 156, 156, 155, 155, 154, 154, 153, 153, 152, 152, 151, 151, 150, 150, 149, 149, 148, 148, 148, 147, 147, 146, 146, 145, 145, 144, 144, 143, 143, 142, 142, 141, 141, 140, 140, 139, 139, 138, 138, 138, 137, 137, 136, 136, 135, 135, 134, 134, 133, 133, 132, 132, 131, 131, 130, 130, 129, 129, 128, 128, 127, 127, 127, 126, 126, 125, 125, 124, 124, 123, 123, 122, 122, 121, 121, 120, 120, 119, 119, 118, 118, 117, 117, 116, 116, 116, 115, 115, 114, 114, 113, 113, 112, 112, 111, 111, 110, 110, 109, 109, 108, 108, 107, 107, 106, 106, 106, 105, 105, 104, 104, 103, 103, 102, 102, 101, 101, 100, 100, 99, 99, 98, 98, 97, 97, 96, 96, 95, 95, 95, 94, 94, 93, 93, 92, 92, 91, 91, 90, 90, 89, 89, 88, 88, 87, 87, 86, 86, 85, 85, 85, 84, 84, 83, 83, 82, 82, 81, 81, 80, 80, 79, 79, 78, 78, 77, 77, 76, 76, 75, 75, 74, 74, 74, 73, 73, 72, 72, 71, 71, 70, 70, 69, 69, 68, 68, 67, 67, 66, 66, 65, 65, 64, 64, 63, 63, 63, 62, 62, 61, 61, 60, 60, 59, 59, 58, 58, 57, 57, 56, 56, 55, 55, 54, 54, 53, 53, 53, 52, 52, 51, 51, 50, 50, 49, 49, 48, 48, 47, 47, 46, 46, 45, 45, 44, 44, 43, 43, 42, 42, 42, 41, 41, 40, 40, 39, 39, 38, 38, 37, 37, 36, 36, 35, 35, 34, 34, 33, 33, 32, 32, 32, 31, 31, 30, 30, 29, 29, 28, 28, 27, 27, 26, 26, 25, 25, 24, 24, 23, 23, 22, 22, 21, 21, 21, 20, 20, 19, 19, 18, 18, 17, 17, 16, 16, 15, 15, 14, 14, 13, 13, 12, 12, 11, 11, 10, 10, 10, 9, 9, 8, 8, 7, 7, 6, 6, 5, 5, 4, 4, 3, 3, 2, 2, 1, 1, 0, 0, 0, -1, -1, -2, -2, -3, -3, -4, -4, -5, -5, -6, -6};
const short gyro_r180_low[391]={-180, -180, -179, -179, -178, -178, -177, -177, -176, -176, -175, -175, -174, -174, -173, -173, -172, -172, -171, -171, -170, -170, -169, -169, -169, -168, -168, -167, -167, -166, -166, -165, -165, -164, -164, -163, -163, -162, -162, -161, -161, -160, -160, -159, -159, -159, -158, -158, -157, -157, -156, -156, -155, -155, -154, -154, -153, -153, -152, -152, -151, -151, -150, -150, -149, -149, -148, -148, -148, -147, -147, -146, -146, -145, -145, -144, -144, -143, -143, -142, -142, -141, -141, -140, -140, -139, -139, -138, -138, -138, -137, -137, -136, -136, -135, -135, -134, -134, -133, -133, -132, -132, -131, -131, -130, -130, -129, -129, -128, -128, -127, -127, -127, -126, -126, -125, -125, -124, -124, -123, -123, -122, -122, -121, -121, -120, -120, -119, -119, -118, -118, -117, -117, -116, -116, -116, -115, -115, -114, -114, -113, -113, -112, -112, -111, -111, -110, -110, -109, -109, -108, -108, -107, -107, -106, -106, -106, -105, -105, -104, -104, -103, -103, -102, -102, -101, -101, -100, -100, -99, -99, -98, -98, -97, -97, -96, -96, -95, -95, -95, -94, -94, -93, -93, -92, -92, -91, -91, -90, -90, -89, -89, -88, -88, -87, -87, -86, -86, -85, -85, -85, -84, -84, -83, -83, -82, -82, -81, -81, -80, -80, -79, -79, -78, -78, -77, -77, -76, -76, -75, -75, -74, -74, -74, -73, -73, -72, -72, -71, -71, -70, -70, -69, -69, -68, -68, -67, -67, -66, -66, -65, -65, -64, -64, -63, -63, -63, -62, -62, -61, -61, -60, -60, -59, -59, -58, -58, -57, -57, -56, -56, -55, -55, -54, -54, -53, -53, -53, -52, -52, -51, -51, -50, -50, -49, -49, -48, -48, -47, -47, -46, -46, -45, -45, -44, -44, -43, -43, -42, -42, -42, -41, -41, -40, -40, -39, -39, -38, -38, -37, -37, -36, -36, -35, -35, -34, -34, -33, -33, -32, -32, -32, -31, -31, -30, -30, -29, -29, -28, -28, -27, -27, -26, -26, -25, -25, -24, -24, -23, -23, -22, -22, -21, -21, -21, -20, -20, -19, -19, -18, -18, -17, -17, -16, -16, -15, -15, -14, -14, -13, -13, -12, -12, -11, -11, -10, -10, -10, -9, -9, -8, -8, -7, -7, -6, -6, -5, -5, -4, -4, -3, -3, -2, -2, -1, -1, 0, 0, 0, 1, 1, 2, 2, 3, 3, 4, 4, 5, 5, 6, 6};

	
	#endif

 
u8 test=0;
void __mouseCoorUpdate (void)
{	 
    switch (GucMouseDir) {

    case 0:
        GmcMouse.cY++;
        break;

    case 1:
        GmcMouse.cX++;
        break;

    case 2:
        GmcMouse.cY--;
        break;

    case 3:
        GmcMouse.cX--;
        break;

    default:
        break;
    }
 
	 
    __wallCheck();
	 
}

 
void __mouseCoorUpdate_Fast (u8 num)
{	 
    switch (GucMouseDir) {

    case 0:
        GmcMouse.cY+=num;
        break;

    case 1:
        GmcMouse.cX+=num;
        break;

    case 2:
        GmcMouse.cY-=num;
        break;

    case 3:
        GmcMouse.cX-=num;
        break;

    default:
        break;
    }
 
	 
    __wallCheck();
	 
}

 
void __wallCheck (void)
{
    uchar ucMap = 0;
	uchar temp,temp1;
       
	
    GucMapGet[GmcMouse.cX][GmcMouse.cY]=1;
    
    ucMap |= MOUSEWAY_B;                               
    if (lefthaswall==1) {                
        ucMap &= ~MOUSEWAY_L;                          
    }else {
        ucMap |=  MOUSEWAY_L;                        
    }
    if (forwardhaswall==1) {
        ucMap &= ~MOUSEWAY_F;                          
    }else {
        ucMap |=  MOUSEWAY_F;                         
    }
    if (righthaswall==1) {
        ucMap &= ~MOUSEWAY_R;                          
    }else {
        ucMap |=  MOUSEWAY_R;                         
    }
	ucMap=(ucMap&0x0F);
    temp1 = ucMap;                     
	temp=(temp1<<4);
	ucMap=(ucMap|temp);
                                                       
    if ((GucMapBlock[GmcMouse.cX][GmcMouse.cY]&0x0f) == 0x00) 
    {                 
        GucMapBlock[GmcMouse.cX][GmcMouse.cY] = ucMap; 
	        
	    if( GmcMouse.cX >0 )
	    {
	         if( (GucMapBlock[GmcMouse.cX][GmcMouse.cY]&0x08) == 0x00 )                 //0x08
	         {
	          GucMapBlock[GmcMouse.cX-1][GmcMouse.cY]=((GucMapBlock[GmcMouse.cX-1][GmcMouse.cY])&0xdf);                          
	         }
	     }
	        
	    if( GmcMouse.cX < MAZETYPE-1 )
	    {   if( (GucMapBlock[GmcMouse.cX][GmcMouse.cY]&0x02) == 0x00 )                   
	        {
	          GucMapBlock[GmcMouse.cX+1][GmcMouse.cY]=((GucMapBlock[GmcMouse.cX+1][GmcMouse.cY])&0x7f);                          
	        }
	    }   
	    
	    if( GmcMouse.cY >0 )    
	    {       if( (GucMapBlock[GmcMouse.cX][GmcMouse.cY]&0x04) == 0x00 )                  
	        {
	          GucMapBlock[GmcMouse.cX][GmcMouse.cY-1]=((GucMapBlock[GmcMouse.cX][GmcMouse.cY-1])&0xef);                          
	        }
	    }
	    
	    if( GmcMouse.cY < MAZETYPE-1 ) 
	    {   
			if( (GucMapBlock[GmcMouse.cX][GmcMouse.cY]&0x01) == 0x00 )                   
	        {
	          GucMapBlock[GmcMouse.cX][GmcMouse.cY+1]=((GucMapBlock[GmcMouse.cX][GmcMouse.cY+1])&0xbf);                          
	        } 
	    }
    }       
}

u8 breakornot() 
{
	if(forwardhaswall==1)return 1;
	else if(lefthaswall==0)return 1;
	else if(righthaswall==0)return 1;
	else return 0;
}

u8 keyCheck()
{
	delay_ms(1000);
	return 1;
}

int abovezero(int t)
{
	if(t>=0)return t;
	else return 0;
}

void settrack(int t) 
{
	basetrack=absolutetrack-t;
	track=t;
}

void setangle(int a) 
{
	ganglet=-a*gangleratio*(-1);
	baseangle=absoluteangle+a; 	
}

 
u16 accdistance=40;
extern double accratio;
void taskacc()
{
	settrack(0);
	e=0;eh=0;
 	accratio=(double)(speed_turn-ACCV0)/accdistance; 
	while(track<accdistance) task=ACC;
}

extern double decratio;
u16 decdistance=5;
void taskstop()
{
	settrack(-decdistance);
	eh=0;
	e=0;
	tick=0;
	stoptick=0;
	decratio=(double)speed/decdistance;	
	while(tick<3)
	{
		task=STOP;
		if(stoptick>30) break; 
	}
	settrack(0);
}

void taskgostraight(u16 dis)
{
	eh=0;
	e=0;
	while(track<dis) task=GOSTRAIGHT;
}

void taskslowdown(u16 dis)
{
	long begintrack;
	e=0;eh=0;tick=0;
	begintrack=absolutetrack;
	while(speed>speed_turn && absolutetrack-begintrack<dis) task=SLOWDOWN;
	while(absolutetrack-begintrack<dis)      task=GOSTRAIGHT;
}

void taskspeedup(u16 dis)
{
	long begintrack;
	e=0;eh=0;tick=0;
	begintrack=absolutetrack;
	while(speed<speed_ss && absolutetrack-begintrack<dis) task=SPEEDUP;
	while(absolutetrack-begintrack<dis)
	{
		setvl=speed_ss;
		setvr=speed_ss;
	}
}

void taskturn(u8 pattern)
{
	u16 length;
	eh=0;
	e=0;
	esum=0;
	tick=0;		
	switch(pattern)
	{
		case LT90SPURT:
			setangle(-90);
			turn_gyro=gyro_l_spurt;turn_vl=vinner_spurt;turn_vr=vouter_spurt;
			length=sizeof(gyro_l_spurt);
			break;
		case RT90SPURT:
			setangle(90);
			turn_gyro=gyro_r_spurt;turn_vl=vouter_spurt;turn_vr=vinner_spurt;
			length=sizeof(gyro_r_spurt);	
			break;
		case LT90SEARCH:
			setangle(-90);
			turn_gyro=gyro_l_search;turn_vl=vinner_search;turn_vr=vouter_search;
			length=sizeof(gyro_l_search)-8;
			break;
		case RT90SEARCH:
			setangle(90);
			turn_gyro=gyro_r_search;turn_vl=vouter_search;turn_vr=vinner_search;
			length=sizeof(gyro_r_search);	
			break;
		case POINTL90:
			setangle(-90);
			turn_gyro=gyro_l_point;turn_vl=vinner_point;turn_vr=vouter_point;
			length=sizeof(gyro_l_point)-2;
			break;
		case POINTR90:
			setangle(90);
			turn_gyro=gyro_r_point;turn_vl=vouter_point;turn_vr=vinner_point;
			length=sizeof(gyro_r_point);	
			break;
		#ifdef LOW_ENABLE
		case LT90L:
			setangle(-90);
			turn_gyro=gyro_lt90_low;turn_vl=vinner_t90_low;turn_vr=vouter_t90_low;
			length=sizeof(gyro_lt90_low)-16;
			break;
		case RT90L:
			setangle(90);
			turn_gyro=gyro_rt90_low;turn_vl=vouter_t90_low;turn_vr=vinner_t90_low;
			length=sizeof(gyro_rt90_low)-4;	
			break;
		case LV90L: 
			setangle(-90);
			turn_gyro=gyro_lv90_low;turn_vl=vinner_v90_low;turn_vr=vouter_v90_low;
			length=sizeof(gyro_lv90_low);	
			break;
		case RV90L: 
			setangle(90);
			turn_gyro=gyro_rv90_low;turn_vl=vouter_v90_low;turn_vr=vinner_v90_low;
			length=sizeof(gyro_rv90_low);	
			break;
		case LT45L: 
			setangle(-45);
			turn_gyro=gyro_lt45_low;turn_vl=vinner_t45_low;turn_vr=vouter_t45_low;
			length=sizeof(gyro_lt45_low);	
			break;
		case RT45L: 
			setangle(45);
			turn_gyro=gyro_rt45_low;turn_vl=vouter_t45_low;turn_vr=vinner_t45_low;
			length=sizeof(gyro_rt45_low);	
			break;
		case LV45L: 
			setangle(-45);
			turn_gyro=gyro_lv45_low;turn_vl=vinner_v45_low;turn_vr=vouter_v45_low;
			length=sizeof(gyro_lv45_low)-14;	
			break;
		case RV45L: 
			setangle(45);
			turn_gyro=gyro_rv45_low;turn_vl=vouter_v45_low;turn_vr=vinner_v45_low;
			length=sizeof(gyro_rv45_low)-8;	
			break;
		case LT135L: 
			setangle(-135);
			turn_gyro=gyro_lt135_low;turn_vl=vinner_t135_low;turn_vr=vouter_t135_low;
			length=sizeof(gyro_lt135_low);	
			break;
		case RT135L: 
			setangle(135);
			turn_gyro=gyro_rt135_low;turn_vl=vouter_t135_low;turn_vr=vinner_t135_low;
			length=sizeof(gyro_rt135_low);	
			break;
		case LV135L: 
			setangle(-135);
			turn_gyro=gyro_lv135_low;turn_vl=vinner_v135_low;turn_vr=vouter_v135_low;
			length=sizeof(gyro_lv135_low);	
			break;
		case RV135L: 
			setangle(135);
			turn_gyro=gyro_rv135_low;turn_vl=vouter_v135_low;turn_vr=vinner_v135_low;
			length=sizeof(gyro_rv135_low)+8;	
			break;
		case L180L: 
			setangle(-180);
			turn_gyro=gyro_l180_low;turn_vl=vinner_180_low;turn_vr=vouter_180_low;
			length=sizeof(gyro_l180_low);	
			break;		 
		case R180L:
			setangle(180);
			turn_gyro=gyro_r180_low;turn_vl=vouter_180_low;turn_vr=vinner_180_low;
			length=sizeof(gyro_r180_low);	
			break;
		#endif
	}
	task=TURN;
	while(tick<length/2-2);
	settrack(0);
}


void taskturnaround()
{ 
	if(GmcMouse.cX==0&&GmcMouse.cX==0)
	{
		taskgostraight(30);
	}
	setangle(180);
	turn_gyro=gyro_around;
	turn_vl=vl_around;
	turn_vr=vr_around;
	eh=0;
	e=0;
	tick=0;step=0;
	task=TURNAROUND;
	while(1)
		if(step==1 && tick>30) break; 
	settrack(0);	
}

void taskpointturnright()
{
	setangle(90);
	turn_gyro=gyro_r_point;
	turn_vl=vouter_point;
	turn_vr=vinner_point;
	eh=0;
	e=0;
	tick=0;step=0;
	task=POINTTURN90;
	while(1)
		if(step==1 && tick>10) break;
	settrack(0);	
}

void taskpointturnleft()
{
	setangle(-90);
	turn_gyro=gyro_l_point;
	turn_vl=vinner_point;
	turn_vr=vouter_point;
	eh=0;
	e=0;
	tick=0;step=0;
	task=POINTTURN90;
	while(1)
		if(step==1 && tick>10) break;
	settrack(0);	
}




 
 
 
 
void mazeSearch()				 
{	
	if(goaheadbugflag==1) goaheadbugflag=0; 
	eh=0;
	e=0;
	gangleh=0;
	ganglehh=0;
	peakgangle=0;
	peakgangleh=0;
	task=SMARTSTRAIGHT;
	 
	while(1)
	{
#ifdef MOUSE_REMOTE
		if (LP_AbortRequested()) break; /* P2: 协作式中止(SysTick 已强制停轮), 退出搜索循环 */
#endif
		if(track>=180) 
		{	
			blocknum++; 
			 
			settrack(0);
			if(goaheadbugflag==0) __mouseCoorUpdate();
			if(breakornot()==1){blocknum=1;break;}
		}
		if(track>90 && track<180); 
		else
		{		  
			if(lefthaswall==1 || righthaswall==1) mazesearchhaswall(); 
			else if(lefthaswall==0 && righthaswall==0) mazesearchnowall();
		}
	}
}										 

void mazesearchhaswall()		 
{
	turno=0;
	if(disf<10) 
	{
	 	flashwrite=0;
		setvl=0;setvr=0;
		task=NULL;
		delay_ms(300);
	sleepmode=1;
#ifdef MOUSE_REMOTE
	while(1){if (LP_AbortRequested()) return; sleepmode=1;ledoff(0);delay_ms(500);ledon(1);ledon(2);delay_ms(500);}
#else
	while(1){sleepmode=1;ledoff(0);delay_ms(500);ledon(1);ledon(2);delay_ms(500);}
#endif
	}
	
	if(LastSearchAction!=Stright) settrack(track+20);	 
	LastSearchAction=Stright;
	 
	while(track<120+8) task=SMARTSTRAIGHTFAST;			 
	eh=0;e=0;
	while(track<180) task=STRAIGHTEYECLOSECOORADJ;		 
}

void mazesearchnowall()			 
{
	turno=0;
	if(disf<10) 
	{
	 	flashwrite=0;
		setvl=0;setvr=0;
		task=NULL;
		delay_ms(300);
		sleepmode=1;
#ifdef MOUSE_REMOTE
	while(1){if (LP_AbortRequested()) return; sleepmode=1;ledoff(0);delay_ms(500);ledon(3);ledon(4);delay_ms(500);}
#else
		while(1){sleepmode=1;ledoff(0);delay_ms(500);ledon(3);ledon(4);delay_ms(500);}
#endif
	}
	if(LastSearchAction!=Stright) settrack(track+20);
	LastSearchAction=1;
	 

	while(track<120+8) task=GOSTRAIGHT;

	dislpeak=200;
	disrpeak=200;
	lpeakfindenable=0;
	rpeakfindenable=0;
	leftpeaktrack=0;
	rightpeaktrack=0;
	tick=0;
	task=STRAIGHTPOLE;
	while(track<180); 
}

void before90turn(u8 Direction)				 
{
 
 
 
		e=0;eh=0;
		task=BEFORE90TURN;		 
		while(1)
		{
 
		//TURN180	
			if(LastSearchAction==TURN180)					 
			{
				if(Direction==TurnLeft)						 
				{
					if(track>=turn_delay+27) //20
					{
						turno=0; break;
					}
				}
				else
				{
					if(track>=turn_delay+20)						 
					{
						turno=0; break;
					}
				}
			} 
			
			
			if(LastSearchAction==Stright)					 
			{
				if(Direction==TurnLeft)						 
				{
					if(track>=turn_delay-2)
					{
						turno=0; break;
					}
				}
				else
				{
					if(track>=turn_delay-3)						 //3
					{
						turno=0; break;
					}
				}
			}
			else if(LastSearchAction==TurnLeft)
			{
				if(Direction==TurnLeft)						 
				{
					if(track>=turn_delay)
					{
						turno=0; break;
					}
				}
				else
				{
					if(track>=turn_delay-5)						  //3
					{
						turno=0; break;
					}
				}
			}
			else if(LastSearchAction==TurnRight)
			{
				if(Direction==TurnLeft)					 
				{
					if(track>=turn_delay-4)    //2
					{
						turno=0; break;
					}
				}
				else
				{
					if(track>=turn_delay-1)						 
					{
						turno=0; break;
					}
				}
			}
		}
 
}										 

u16 disbf180;
void before180turn()			 
{
	settrack(0);
	task=SMARTSTRAIGHT;
	while(track<5);				 
	if(lefthaswall==1) afterturn_flag=1;
	else if(righthaswall==1) afterturn_flag=2;
		else afterturn_flag=0;
	while(track<5);

	if(forwardhaswall==0)			 
	{
	if(LastSearchAction==Stright) taskgostraight(5);	 
		else taskgostraight(20);	 
		disbf180=absolutetrack;
		decdistance=10; taskstop(); decdistance=10;
		disbf180=absolutetrack-disbf180+30;				 
	}
	else if(forwardhaswall==1) 
	{					   
		tick=0;
		turnaround_tick=0;
		taskgostraight(10);
		task=BEFORE180TURN;
	 	while(tick<5);
		disbf180=90;
	}

	settrack(0);
	LastSearchAction=TURN180;
}										 
						 

void after180turn()				 
{
 
//	if( (lefthaswall==1 && abs(disl-dis2wall)<9) || (righthaswall==1 && abs(disr-dis2wall)<9) || afterturn_flag==0 ) 
 
//	{
//		taskacc();			 
//		taskgostraight(disbf180-35);
//	}
//	else 
/*		if((GmcMouse.cX==GoalX)&&(GmcMouse.cY==GoalY))
		{
			if((GmcMouse.cX+GmcMouse.cY+GucMouseDir)%2==0)
			{
				taskturn(POINTR90);
				tick=0;
				turnaround_tick=0;
				task=KEEPWALLDISTANCE;
				while(tick<5);
				 
				taskpointturnleft();
				taskacc();			 
				taskgostraight(disbf180-35);
			}
			else 
			{
				taskturn(POINTL90);
				tick=0;
				turnaround_tick=0;
				task=KEEPWALLDISTANCE;
				while(tick<5);
				 
				taskpointturnright();
				taskacc();			 
				taskgostraight(disbf180-35);
			}
		}
		*/
	 if(afterturn_flag==2)
		{
			taskturn(POINTL90);
			tick=0;
			turnaround_tick=0;
			task=KEEPWALLDISTANCE;
			while(tick<10);
			 
			taskpointturnright();
			taskacc();			 
			taskgostraight(disbf180-35);
		}
		else if(afterturn_flag==1)
			{
				taskturn(POINTR90);
				tick=0;
				turnaround_tick=0;
				task=KEEPWALLDISTANCE;
				while(tick<10);
				 
				taskpointturnleft();
				taskacc();
				taskgostraight(disbf180-35);
			}
			else 
			{
				taskacc();			 
				taskgostraight(disbf180-35);	
			}
	afterturn_flag=0;
}									 

void mouseTurnright()
{	 
	goaheadbugflag=0;
	before90turn(TurnRight);
	LastSearchAction=TurnRight;
	if(lefthaswall==1)
	{
		turnrighto=dis2wall-((disl+dislh+dislhh)/3);
		turno=(disr+disrh+disrhh)/3-dis2wall;
	}
	else {turnrighto=0;turno=0;}
	if(disr<50) 
	{
		flashwrite=0;
	 	setvl=0;setvr=0;
		task=NULL;
		delay_ms(50);
		sleepmode=1;
		while(1){sleepmode=1;ledoff(0);delay_ms(500);ledon(7);ledon(8);delay_ms(500);}
	}
	taskturn(RT90SEARCH);
	task=SMARTSTRAIGHT;
	GucMouseDir=(GucMouseDir + 1) % 4; 
	settrack(180-turnrighto); 

 
}

void mouseTurnleft()
{	 
	goaheadbugflag=0;
	before90turn(TurnLeft);
	LastSearchAction=TurnLeft;
	if(righthaswall==1)
	{
		turnlefto=(disr+disrh+disrhh)/3-dis2wall;
		turno=(disr+disrh+disrhh)/3-dis2wall;
	}
	else {turnlefto=0;turno=0;}
	if(disl<50) 
	{
	 	flashwrite=0;
		setvl=0;setvr=0;
		task=NULL;
	delay_ms(50);
		sleepmode=1;
		while(1){sleepmode=1;ledoff(0);delay_ms(500);ledon(5);ledon(6);delay_ms(500);}
	}		   	
	taskturn(LT90SEARCH);
	task=SMARTSTRAIGHT;
	GucMouseDir=(GucMouseDir + 3) % 4;
	settrack(180+turnlefto);


}

void mouseTurnback()
{				
	goaheadbugflag=0;
	before180turn();
	LastSearchAction=Stright;
	taskturnaround();
	if(block_write_flag==1)
	{
		SaveBlockData(); 
		block_write_flag=0;
	}
		if((GmcMouse.cX!=GoalX)||(GmcMouse.cY!=GoalY))
		{
	after180turn();
		}
	GucMouseDir = (GucMouseDir + 2) % 4;
	__mouseCoorUpdate();
	settrack(0);
}

void specialmouseTurnback()
{				
	goaheadbugflag=0;
	before180turn();
	taskturnaround();
	GucMouseDir = (GucMouseDir + 2) % 4;
	settrack(0);
}


void mouseGoahead(char cNBlock)	 
{	   
	u8 n=0;			 
	goaheadbugflag=1;
	eh=0;
	e=0;
	gangleh=0;
	ganglehh=0;
	peakgangle=0;
	peakgangleh=0;
	task=SMARTSTRAIGHT;
	while(1)
	{
#ifdef MOUSE_REMOTE
		if (LP_AbortRequested()) break; /* P2: 协作式中止(SysTick 已强制停轮), 退出搜索循环 */
#endif
		if(track>=180) 
		{	
			blocknum++; 
			settrack(0);
			__mouseCoorUpdate();
			n++;
			if(n==cNBlock)
			{
				blocknum=1;
				break;
			}
		}
		if(track>90&&track<180); 
		else
		{	  
			if(lefthaswall==1 || righthaswall==1) mazesearchhaswall();	 
			else if(lefthaswall==0 && righthaswall==0) mazesearchnowall();
		}
	}
}


 
 
 
void spurt(u8 mode)
{
	if(mode==LOW)
	{
		SPURT90IR_kp1=0.17;   //0.25
		SPURT90IR_kp2=0.1;   //0.15
		SPURT90IR_kd=0;
		SPURT90GYRO_kp=0.3;
		SPURT90GYRO_kd=0;
		STRAIGHT45_kp=0.07; //0.07
		STRAIGHT45_kd=0.05; //0.03
		turn_kp=4;   //8
		turn_kd=2;    //5
	}
	else if(mode==MEDIUM)
	{
		SPURT90IR_kp1=0.25;
		SPURT90IR_kp2=0.15;
		SPURT90IR_kd=0;
		SPURT90GYRO_kp=0.3;
		SPURT90GYRO_kd=0;
		STRAIGHT45_kp=0.1;
		STRAIGHT45_kd=0.1;
		turn_kp=8;
		turn_kd=5;
	}
	else if(mode==HIGH)
	{	
		SPURT90IR_kp1=0.3;
		SPURT90IR_kp2=0.15;
		SPURT90IR_kd=0;
		SPURT90GYRO_kp=0.3;
		SPURT90GYRO_kd=0;
		STRAIGHT45_kp=0.1;
		STRAIGHT45_kd=0.1;
		turn_kp=10;
		turn_kd=7;
	}
	
	actiongenerate(mode);
	action(mode);
}

void spurt_90(u8 mode)
{   
	 
 
 
 
 
 
 
 
 
 
	
	actiongenerate_90(mode);
	action_90(mode);
}

void test_spurt90(u8 mode,float IR_p1,float IR_p2,float IR_d,float GYRO_p,float GYRO_d,double turn_p,double turn_d,u16 spd_turn,u16 spd_fastss)
{
	
	SPURT90IR_kp1=IR_p1; 
	SPURT90IR_kp2=IR_p2;
	SPURT90IR_kd=IR_d;
	SPURT90GYRO_kp=GYRO_p;
	SPURT90GYRO_kd=GYRO_d;
	turn_kp=turn_p;
	turn_kd=turn_d;
	speed_turn=spd_turn;
	speed_fastss=spd_fastss;
	
	spurt_90(mode);
}
	


int L45TopSpeed=130,L45BottomSpeed=100;  //160，100  //132  100

void taskstraight45	(u16 dis)
{
	settrack(0);
	eh=0;
	e=0;
	gangleh=0;
	ganglehh=0;
	peakgangle=0;
	peakgangleh=0;
	ganglet=0;
	task=STRAIGHT45;
	while(track<dis)
	{
		if(speedmode==LOW)
		{
				if(dis > 180)
				{
					if(track < 90)
						speed_fastss=(L45TopSpeed-L45BottomSpeed)*track/90+L45BottomSpeed;
					else if(track < dis-90)
						speed_fastss=L45TopSpeed;
					else if(track < dis)
						speed_fastss=(L45TopSpeed-L45BottomSpeed)*(dis-track)/90+L45BottomSpeed;
				}
				else speed_fastss=L45BottomSpeed;
		}
	}
}

int ObjectGoTo_TopSpeed=90,ObjectGoTo_BottomSpeed=90;
int LTopSpeed=140,LBottomSpeed=95;    //160   100
int L90TopSpeed=90,L90BottomSpeed=90;   
int BackTopSpeed=70,BackBottomSpeed=70;
int TopSpeed,BottomSpeed;
float SpurtAccRatio45=0.7,SpurtDecRatio45=0.7;     //0.6  0.5
float SpurtAccRatio90=0.8,SpurtDecRatio90=0.5;
float SpurtAccRatio,SpurtDecRatio;
int InitialSpeed=0;

void taskstraight90(u16 dis)
{
	turno=0;
	eh=0;
	e=0;
	settrack(0);
	InitialSpeed=speed;
  task=SPURT90IR;
	while(track<dis)
	{
		if(InitialSpeed < 50)									 
		{
			SPURT90IR_kp1=0.31;
			SPURT90IR_kp2=0.21;
			SPURT90IR_kd=0.1;
			SPURT90GYRO_kp=0.28;
			SPURT90GYRO_kd=0.10;
			if(GoOrBackFlag==1)								 
			{
				TopSpeed=BackTopSpeed;
				BottomSpeed=BackBottomSpeed;
				SpurtAccRatio=SpurtAccRatio90;
				SpurtDecRatio=SpurtDecRatio90;
			}
			else
			{
				if(speedmode==LOW_90)						 
				{
					TopSpeed=L90TopSpeed;
					BottomSpeed=L90BottomSpeed;
					SpurtAccRatio=SpurtAccRatio90;
					SpurtDecRatio=SpurtDecRatio90;
				}

				if(speedmode==LOW)							 
				{
					TopSpeed=LTopSpeed;
					BottomSpeed=LBottomSpeed;
					SpurtAccRatio=SpurtAccRatio45;
					SpurtDecRatio=SpurtDecRatio45;
				}
			}
			if(track < BottomSpeed/(SpurtAccRatio+0.2))
				speed_ss=(SpurtAccRatio+0.2)*track;
			else if(track < (dis-(BottomSpeed/(SpurtAccRatio+0.2)))*(SpurtDecRatio/(SpurtAccRatio+SpurtDecRatio))+(BottomSpeed/(SpurtAccRatio+0.2)))
				speed_ss=SpurtAccRatio*(track-(BottomSpeed/(SpurtAccRatio+0.2)))+BottomSpeed;
			else
				speed_ss=SpurtDecRatio*(dis-track)+BottomSpeed;
			if(speed_ss < 10)
				speed_ss=10;
			if(speed_ss > TopSpeed)
				speed_ss=TopSpeed;
		}
		else
		{
			if(ObjectGoTo_Flag==1)							 
			{
				SPURT90IR_kp1=0.5;
				SPURT90IR_kp2=0.35;
				SPURT90IR_kd=2;
				SPURT90GYRO_kp=0.4;
				SPURT90GYRO_kd=0.4;
				if(dis > 180)
				{
					if(track < 100)
						speed_ss=(ObjectGoTo_TopSpeed-ObjectGoTo_BottomSpeed)*track/100+ObjectGoTo_BottomSpeed;
					else if(track > dis-80 && track < dis)
						speed_ss=(ObjectGoTo_TopSpeed-ObjectGoTo_BottomSpeed)*(dis-track)/80+ObjectGoTo_BottomSpeed;
				}
				else speed_ss=ObjectGoTo_BottomSpeed;	
			}			
			else
			{
				if(GoOrBackFlag==1)							 
				{
					SPURT90IR_kp1=0.5;
					SPURT90IR_kp2=0.35;
					SPURT90IR_kd=1;
					SPURT90GYRO_kp=0.25;
					SPURT90GYRO_kd=0.08;
					TopSpeed=BackTopSpeed;
					BottomSpeed=BackBottomSpeed;
					SpurtAccRatio=SpurtAccRatio90;
					SpurtDecRatio=SpurtDecRatio90;
				}
				else
				{
					if(speedmode==LOW_90)					 
					{
						SPURT90IR_kp1=0.4;
						SPURT90IR_kp2=0.3;
						SPURT90IR_kd=0.3;
						SPURT90GYRO_kp=0.25;
						SPURT90GYRO_kd=0.08;
						TopSpeed=L90TopSpeed;
						BottomSpeed=L90BottomSpeed;
						SpurtAccRatio=SpurtAccRatio90;
						SpurtDecRatio=SpurtDecRatio90;
					}

					if(speedmode==LOW)						 
					{
						SPURT90IR_kp1=0.3; //0.3
						SPURT90IR_kp2=0.3;  //0.3
						SPURT90IR_kd=0.3;
						SPURT90GYRO_kp=0.4;
						SPURT90GYRO_kd=0.4;
						TopSpeed=LTopSpeed;
						BottomSpeed=LBottomSpeed;
						SpurtAccRatio=SpurtAccRatio45;
						SpurtDecRatio=SpurtDecRatio45;
					}
				}
				if(track < dis*(0.5/(0.6+0.5)))
					speed_ss=SpurtAccRatio*track*1.5+BottomSpeed;
				else
					speed_ss=SpurtDecRatio*(dis-track)*5+BottomSpeed;
				if(speed_ss > TopSpeed)
					speed_ss=TopSpeed;
			}
		}
		if(track%180>20 && track%180<100) task=SPURT90BLIND;		 
		else
		{
			if(lefthaswall==1 || righthaswall==1) task=SPURT90IR;	 
			else task=SPURT90BLIND;									 
		}
		if(disf<20) isemergency=1;
	}
}

 
void beforemouseturn(u8 pattern)
{
	int beforeturntrack;
	e=0;eh=0;
	switch(pattern)
	{
		 
		case LV45L:	beforeturntrack=3; speed_fastss=100;	goto BFLV;    //3
		case LV90L:	beforeturntrack=7; speed_fastss=100;	goto BFLV;
		case LV135L:beforeturntrack=0; speed_fastss=100;	goto BFLV;    //9
		case RV45L:	beforeturntrack=3; speed_fastss=100;	goto BFRV;     //3
		case RV90L:	beforeturntrack=7; speed_fastss=100;	goto BFRV;
		case RV135L:beforeturntrack=0; speed_fastss=100;	goto BFRV;      //9
		
		case LT45L:	beforeturntrack=0; speed_ss=100;
					sidewall_threshold=110;					goto BFL;
		case LT90L:	beforeturntrack=60;speed_ss=70;		goto BFL;  //10
		case LT135L:beforeturntrack=14;speed_ss=100;		goto BFL;
		case L180L:	beforeturntrack=0; speed_ss=100;		goto BFL;
		
		case RT45L:	beforeturntrack=0; speed_ss=100;
					sidewall_threshold=110;					goto BFR;
		case RT90L:	beforeturntrack=65;speed_ss=70;		goto BFR;
		case RT135L:beforeturntrack=13;speed_ss=100;		goto BFR;   //14
		case R180L:	beforeturntrack=0; speed_ss=100;		goto BFR;

		 
		case LV45M:beforeturntrack=7;	goto BFLV;
		case LV90M:beforeturntrack=7;	goto BFLV;
		case LV135M:beforeturntrack=7;	goto BFLV;
		case RV45M:beforeturntrack=7;	goto BFRV;
		case RV90M:beforeturntrack=7;	goto BFRV;
		case RV135M:beforeturntrack=7;	goto BFRV;
		
		case LT45M:beforeturntrack=0;	goto BFL;
		case LT90M:beforeturntrack=23;	goto BFL;
		case LT135M:beforeturntrack=23;	goto BFL;
		case L180M:beforeturntrack=0;	goto BFL;
		
		case RT45M:beforeturntrack=0;	goto BFR;
		case RT90M:beforeturntrack=23;	goto BFR;
		case RT135M:beforeturntrack=23;	goto BFR;
		case R180M:beforeturntrack=0;	goto BFR;

		 
		case LV45H:beforeturntrack=0;	goto BFLV;
		case LV90H:beforeturntrack=0;	goto BFLV;
		case LV135H:beforeturntrack=0;	goto BFLV;
		case RV45H:beforeturntrack=0;	goto BFRV;
		case RV90H:beforeturntrack=0;	goto BFRV;
		case RV135H:beforeturntrack=0;	goto BFRV;
		
		case LT45H:beforeturntrack=0;	goto BFL;
		case LT90H:beforeturntrack=0;	goto BFL;
		case LT135H:beforeturntrack=0;	goto BFL;
		case L180H:beforeturntrack=0;	goto BFL;
		
		case RT45H:beforeturntrack=0;	goto BFR;
		case RT90H:beforeturntrack=0;	goto BFR;
		case RT135H:beforeturntrack=0;	goto BFR;
		case R180H:beforeturntrack=0;	goto BFR;	
				
BFLV:
		while(1)
		{
			task=STRAIGHT45;
			if(leftwallcriticalhhh==1 && leftwallcriticalhh==1 && leftwallcriticalh==1 && leftwallcritical==0) break;
#ifdef MOUSE_REMOTE
			if (LP_AbortRequested()) break; /* P2: 墙沿跳变判据在中止停轮后冻结, 给出中止出口 */
#endif
		}
		settrack(0);
		while(track<beforeturntrack)task=STRAIGHT45;
		break;
BFRV:
		while(1)
		{
			task=STRAIGHT45;
			if(rightwallcriticalhhh==1 && rightwallcriticalhh==1 && rightwallcriticalh==0 && rightwallcritical==0) break;
#ifdef MOUSE_REMOTE
			if (LP_AbortRequested()) break; /* P2: 墙沿跳变判据在中止停轮后冻结, 给出中止出口 */
#endif
		}
		settrack(0);
		while(track<beforeturntrack) task=STRAIGHT45;
		break;				
BFL:
		while(1)
		{
			task=SMARTSTRAIGHTSPURTL;
			if(lefthaswallh==1 && lefthaswall==0) break;
#ifdef MOUSE_REMOTE
			if (LP_AbortRequested()) break; /* P2: 墙沿跳变判据在中止停轮后冻结, 给出中止出口 */
#endif
		}
		sidewall_threshold=160;
		settrack(0);
		while(track<beforeturntrack) task=SMARTSTRAIGHTSPURTL;
		break;
BFR:
		while(1)
		{
			task=SMARTSTRAIGHTSPURTL;
			if( righthaswallh==1 && righthaswall==0) break;
#ifdef MOUSE_REMOTE
			if (LP_AbortRequested()) break; /* P2: 墙沿跳变判据在中止停轮后冻结, 给出中止出口 */
#endif
		}
		sidewall_threshold=160;
		settrack(0);
		while(track<beforeturntrack) task=SMARTSTRAIGHTSPURTL;
		break;
	}
}

void mouseturn(u8 pattern)		 
{
	beforemouseturn(pattern);
	taskturn(pattern);
	ledoff(0);
	speed_ss=70; speed_fastss=100;
}


u16 i=0;
 
 
 
 
 


int getsum(int num)
{
	int ret=0,i=0;
	for(i=0;i<=num;i++) ret+=FastwayAction[i].action;
	return ret;
}

int getfinaldir()
{
	int ret=0,i=0;
	for(i=0;i<FastwayCount;i++)
	{
		if(FastwayAction[i].action==7) ret+=-1;
		else if(FastwayAction[i].action==6) ret+=-2;
		else ret+=FastwayAction[i].action;
	}
	return ret%8;
}

void actiongenerate(u8 mode)	 
{
	int sum=0,current=0;
	u16 i=0,j=0;
 
	uchar k=0,dirtemp=0,leftdir=0,rightdir=0;
	for(i=0;i<200;i++)
	{
		actionsequence[i]=0;
		action_correct_sequence[i]=0;
	}
 

	if(mode==LOW)
	{  	
		for(i=0;i<FastwayCount-1;i++) 
		{	
			if(i<current)continue;
	
			if(FastwayAction[i+1].action==1  && FastwayAction[i+2].action==2 && FastwayAction[i+3].action==1 && getsum(i)%2==0){actionsequence[j++]=R180L;current+=3;}
			else if(FastwayAction[i+1].action==7 && FastwayAction[i+2].action==6 && FastwayAction[i+3].action==7 && getsum(i)%2==0){actionsequence[j++]=L180L;current+=3;}
			else if(FastwayAction[i+1].action==2 && FastwayAction[i+2].action==1 && getsum(i)%2==1){actionsequence[j++]=RV135L;current+=2;} 
			else if(FastwayAction[i+1].action==6 && FastwayAction[i+2].action==7 && getsum(i)%2==1){actionsequence[j++]=LV135L;current+=2;}
			else if(FastwayAction[i+1].action==1 && FastwayAction[i+2].action==2 && getsum(i)%2==0){actionsequence[j++]=RT135L;current+=3;} 
			else if(FastwayAction[i+1].action==7 && FastwayAction[i+2].action==6 && getsum(i)%2==0){actionsequence[j++]=LT135L;current+=3;}
			else if(FastwayAction[i+1].action==7 && FastwayAction[i+2].action==7 && getsum(i)%2==0){actionsequence[j++]=LT90L;current+=2;}
			else if(FastwayAction[i+1].action==1 && FastwayAction[i+2].action==1 && getsum(i)%2==0){actionsequence[j++]=RT90L;current+=2;}
			else if(FastwayAction[i+1].action==2 && getsum(i)%2==1){actionsequence[j++]=RV90L;current+=2;}
			else if(FastwayAction[i+1].action==6 && getsum(i)%2==1){actionsequence[j++]=LV90L;current+=2;}
			else if(FastwayAction[i+1].action==1 && getsum(i)%2==0){actionsequence[j++]=RT45L;current+=2;}
			else if(FastwayAction[i+1].action==7 && getsum(i)%2==0){actionsequence[j++]=LT45L;current+=2;}
			else if(FastwayAction[i+1].action==1 && getsum(i)%2==1){actionsequence[j++]=RV45L;current+=1;}
			else if(FastwayAction[i+1].action==7 && getsum(i)%2==1){actionsequence[j++]=LV45L;current+=1;}
			else if(FastwayAction[i+1].action==0 && getsum(i)%2==0)
			{
				actionsequence[j++]=STRAIGHT90L;
 
		/*		if(spurtTestFlag==0)						
				{
					dirtemp=(Mapfastway[FastwayAction[i+1].cx][FastwayAction[i+1].cy])/2;
					leftdir=(dirtemp+3)%4;rightdir=(dirtemp+1)%4;
						
					if( (GucMapBlock[FastwayAction[i+1].cx][FastwayAction[i+1].cy] & (1<<leftdir))
							  && (GucMapBlock[FastwayAction[i+1].cx][FastwayAction[i+1].cy] & (1<<rightdir)))
					{
						action_correct_sequence[j++]=BOTHSIDE;
						if( action_correct_sequence[j-2]==LEFTSIDE||action_correct_sequence[j-1]==RIGHTSIDE )
							action_correct_sequence[j-1]=action_correct_sequence[j-2];
					}
						else if( GucMapBlock[FastwayAction[i+1].cx][FastwayAction[i+1].cy] & (1<<leftdir) )
							{
								action_correct_sequence[j++]=LEFTSIDE;
								for(k=j-2;action_correct_sequence[k]==BOTHSIDE;k--) 
									action_correct_sequence[k]=LEFTSIDE;
							}
						else if( GucMapBlock[FastwayAction[i+1].cx][FastwayAction[i+1].cy] & (1<<rightdir) )
							{
								action_correct_sequence[j++]=RIGHTSIDE;
								for(k=j-2;action_correct_sequence[k]==BOTHSIDE;k--) 
									action_correct_sequence[k]=RIGHTSIDE;
							}
						else action_correct_sequence[j++]=NOSIDE;
				}				*/
 
				current+=1; 
			}
			else if(FastwayAction[i+1].action==0 && getsum(i)%2==1)
				{
					actionsequence[j++]=STRAIGHT45L;current+=1;
				}
		}
	}
	else if(mode==MEDIUM)
	{	 
		for(i=0;i<FastwayCount-1;i++) 
		{	
			if(i<current)continue;
	
			if(FastwayAction[i+1].action==1  && FastwayAction[i+2].action==2 && FastwayAction[i+3].action==1 && getsum(i)%2==0){actionsequence[j++]=R180M;current+=3;}
			else if(FastwayAction[i+1].action==7 && FastwayAction[i+2].action==6 && FastwayAction[i+3].action==7 && getsum(i)%2==0){actionsequence[j++]=L180M;current+=3;}
			else if(FastwayAction[i+1].action==2 && FastwayAction[i+2].action==1 && getsum(i)%2==1){actionsequence[j++]=RV135M;current+=2;} 
			else if(FastwayAction[i+1].action==6 && FastwayAction[i+2].action==7 && getsum(i)%2==1){actionsequence[j++]=LV135M;current+=2;}
			else if(FastwayAction[i+1].action==1 && FastwayAction[i+2].action==2 && getsum(i)%2==0){actionsequence[j++]=RT135M;current+=3;} 
			else if(FastwayAction[i+1].action==7 && FastwayAction[i+2].action==6 && getsum(i)%2==0){actionsequence[j++]=LT135M;current+=3;}
			else if(FastwayAction[i+1].action==7 && FastwayAction[i+2].action==7 && getsum(i)%2==0){actionsequence[j++]=LT90M;current+=2;}
			else if(FastwayAction[i+1].action==1 && FastwayAction[i+2].action==1 && getsum(i)%2==0){actionsequence[j++]=RT90M;current+=2;}
			else if(FastwayAction[i+1].action==2 && getsum(i)%2==1){actionsequence[j++]=RV90M;current+=2;}
			else if(FastwayAction[i+1].action==6 && getsum(i)%2==1){actionsequence[j++]=LV90M;current+=2;}
			else if(FastwayAction[i+1].action==1 && getsum(i)%2==0){actionsequence[j++]=RT45M;current+=2;}
			else if(FastwayAction[i+1].action==7 && getsum(i)%2==0){actionsequence[j++]=LT45M;current+=2;}
			else if(FastwayAction[i+1].action==1 && getsum(i)%2==1){actionsequence[j++]=RV45M;current+=1;}
			else if(FastwayAction[i+1].action==7 && getsum(i)%2==1){actionsequence[j++]=LV45M;current+=1;}
			else if(FastwayAction[i+1].action==0 && getsum(i)%2==0){actionsequence[j++]=STRAIGHT90M;current+=1;}
			else if(FastwayAction[i+1].action==0 && getsum(i)%2==1){actionsequence[j++]=STRAIGHT45M;current+=1;}
		}
	}
	else if(mode==HIGH)
	{
		for(i=0;i<FastwayCount-1;i++)
		{	
			if(i<current)continue;
	
			if(FastwayAction[i+1].action==1  && FastwayAction[i+2].action==2 && FastwayAction[i+3].action==1 && getsum(i)%2==0){actionsequence[j++]=R180H;current+=3;}
			else if(FastwayAction[i+1].action==7 && FastwayAction[i+2].action==6 && FastwayAction[i+3].action==7 && getsum(i)%2==0){actionsequence[j++]=L180H;current+=3;}
			else if(FastwayAction[i+1].action==2 && FastwayAction[i+2].action==1 && getsum(i)%2==1){actionsequence[j++]=RV135H;current+=2;} 
			else if(FastwayAction[i+1].action==6 && FastwayAction[i+2].action==7 && getsum(i)%2==1){actionsequence[j++]=LV135H;current+=2;}
			else if(FastwayAction[i+1].action==1 && FastwayAction[i+2].action==2 && getsum(i)%2==0){actionsequence[j++]=RT135H;current+=3;} 
			else if(FastwayAction[i+1].action==7 && FastwayAction[i+2].action==6 && getsum(i)%2==0){actionsequence[j++]=LT135H;current+=3;}
			else if(FastwayAction[i+1].action==7 && FastwayAction[i+2].action==7 && getsum(i)%2==0){actionsequence[j++]=LT90H;current+=2;}
			else if(FastwayAction[i+1].action==1 && FastwayAction[i+2].action==1 && getsum(i)%2==0){actionsequence[j++]=RT90H;current+=2;}
			else if(FastwayAction[i+1].action==2 && getsum(i)%2==1){actionsequence[j++]=RV90H;current+=2;}
			else if(FastwayAction[i+1].action==6 && getsum(i)%2==1){actionsequence[j++]=LV90H;current+=2;}
			else if(FastwayAction[i+1].action==1 && getsum(i)%2==0){actionsequence[j++]=RT45H;current+=2;}
			else if(FastwayAction[i+1].action==7 && getsum(i)%2==0){actionsequence[j++]=LT45H;current+=2;}
			else if(FastwayAction[i+1].action==1 && getsum(i)%2==1){actionsequence[j++]=RV45H;current+=1;}
			else if(FastwayAction[i+1].action==7 && getsum(i)%2==1){actionsequence[j++]=LV45H;current+=1;}
			else if(FastwayAction[i+1].action==0 && getsum(i)%2==0){actionsequence[j++]=STRAIGHT90H;current+=1;}
			else if(FastwayAction[i+1].action==0 && getsum(i)%2==1){actionsequence[j++]=STRAIGHT45H;current+=1;}
		}
	}
}


void action (u8 mode)
{
 u16 i=0,num=0;

	speedmode=mode;

	if(mode==LOW)
	{	
		#ifndef LOW_ENABLE
		while(1)
		{
			ledoff(0);ledon(1);ledon(8);delay_ms(500);ledoff(0);ledon(3);ledon(6);delay_ms(500);
		}
		#endif
 
		while(actionsequence[i]!=0)
		{
			if(actionsequence[i]==STRAIGHT45L)
			{	
				num=0;
				while(actionsequence[i]==STRAIGHT45L)
				{
				 	num++;
					i++;
					spurt_action_num++;                       //统计STRAIGHT45L斜着走直线冲刺的格数
				}
				taskstraight45(127*num);     //正方形边长为180，斜线距离为127
			}
			else if(actionsequence[i]==STRAIGHT90L)
			{
 
				num=0;
				while(actionsequence[i]==STRAIGHT90L)
				{
				 	num++;
					i++;
					spurt_action_num++;             //直线距离的格数
				}
	      taskstraight90(180*num);  //直线冲刺
			}
			else
			{
				spurt_45_end_flag=0; 			
				mouseturn(actionsequence[i]);
		 		i++;
				spurt_action_num++;
			}
		}
		ledoff(0);ledon(1);ledon(2);ledon(3);ledon(4);
		/*	if(BackSearchFlag==0)
				decdistance=40;
			else if(BackSearchFlag==1)
				decdistance=120+150; 
			else decdistance=120;
			if(spurtTestFlag==1) decdistance=20; 
		
		//taskstop();
		    	settrack(0);

 
 
 
		if(BackSearchFlag==1)
		{tick=0;
			turnaround_tick=0;
			task=KEEPWALLDISTANCE;
			while(tick<50);
		}
 
		ledoff(0);*/
	} 

	if(mode==MEDIUM)
	{	 
		#ifndef MEDIUM_ENABLE
		while(1)
		{
			ledoff(0);ledon(1);ledon(8);delay_ms(500);ledoff(0);ledon(3);ledon(6);delay_ms(500);
		}
		#endif
		 
		while(actionsequence[i]!=0)
		{
			if(actionsequence[i]==STRAIGHT45M)
			{
				num=0;
				while(actionsequence[i]==STRAIGHT45M)
				{
				 	num++;
					i++;
				}
				 
				taskstraight45(127*num); 
			}
			else if(actionsequence[i]==STRAIGHT90M)
			{
				num=0;
				while(actionsequence[i]==STRAIGHT90M)
				{
				 	num++;
					i++;
				}
				taskstraight90(180*num); 
			}
			else
			{
				mouseturn(actionsequence[i]);
		 		i++;
			}
		}
		decdistance=120;
		taskstop();
	}
	if(mode==HIGH)
	{
		#ifndef HIGH_ENABLE
		while(1)
		{
			ledoff(0);ledon(1);ledon(8);delay_ms(500);ledoff(0);ledon(3);ledon(6);delay_ms(500);
		}
		#endif
		 
		while(actionsequence[i]!=0)
		{
			if(actionsequence[i]==STRAIGHT45H)
			{
				num=0;
				while(actionsequence[i]==STRAIGHT45H)
				{
				 	num++;
					i++;
				}
				taskstraight45(127*num); 
			}
			else if(actionsequence[i]==STRAIGHT90H)
			{
				num=0;
				while(actionsequence[i]==STRAIGHT90H)
				{
				 	num++;
					i++;
				}
				taskstraight90(180*num); 
			}
			else
			{
				mouseturn(actionsequence[i]);
		 		i++;
			}
		}
		decdistance=120;
		taskstop();
	}
}


 



void actiongenerate_90(u8 mode)	 
{
	int sum=0,current=0;
	u16 i=0,j=0;
 
	uchar k=0,dirtemp=0,leftdir=0,rightdir=0;
	for(i=0;i<200;i++)
	{actionsequence[i]=0;action_correct_sequence[i]=0;}
 
	if(mode==LOW_90)
	{  	
		for(i=0;i<FastwayCount_90-1;i++) 
		{	
			if(i<current)continue;
			if(FastwayAction_90[i+1].action==1 ){actionsequence[j++]=RT90SEARCH;current+=1;}
			if(FastwayAction_90[i+1].action==3 ){actionsequence[j++]=LT90SEARCH;current+=1;}
			if(FastwayAction_90[i+1].action==0 )
			{
				actionsequence[j]=STRAIGHT_spurt_90;
 
				dirtemp=Mapfastway[FastwayAction[i+1].cx][FastwayAction[i+1].cy];
				leftdir=(dirtemp+3)%4;rightdir=(dirtemp+1)%4;
				
				if( (GucMapBlock[FastwayAction[i+1].cx][FastwayAction[i+1].cy] & (1<<leftdir))
					  && (GucMapBlock[FastwayAction[i+1].cx][FastwayAction[i+1].cy] & (1<<rightdir)))
						{action_correct_sequence[j++]=BOTHSIDE;
						if(action_correct_sequence[j-2]==LEFTSIDE||action_correct_sequence[j-1]==RIGHTSIDE)
						action_correct_sequence[j-1]=action_correct_sequence[j-2];}
				else if( GucMapBlock[FastwayAction[i+1].cx][FastwayAction[i+1].cy] & (1<<leftdir) )
						{action_correct_sequence[j++]=LEFTSIDE;
							for(k=j-2;action_correct_sequence[k]==BOTHSIDE;k--) 
							action_correct_sequence[k]=LEFTSIDE;}
				else if( GucMapBlock[FastwayAction[i+1].cx][FastwayAction[i+1].cy] & (1<<rightdir) )
						{action_correct_sequence[j++]=RIGHTSIDE;
							for(k=j-2;action_correct_sequence[k]==BOTHSIDE;k--) 
							action_correct_sequence[k]=RIGHTSIDE;}
				else action_correct_sequence[j++]=NOSIDE;					
 
				current+=1;
			}
		}
	}
}


void action_90(u8 mode)
{
 	u16 i=0,num=0;

	speedmode=mode;

	if(mode==LOW_90)
	{
		#ifndef LOW_90_ENABLE
		while(1)
		{
			ledoff(0);ledon(1);ledon(8);delay_ms(500);ledoff(0);ledon(3);ledon(6);delay_ms(500);
		}
		#endif
 
		if( (actionsequence[0]==RT90SEARCH) || actionsequence[0]==LT90SEARCH )
		{
 
			if(actionsequence[i]==RT90SEARCH)
			{
				task=SMARTSTRAIGHT;
				while(1)
					if(righthaswallh==1 && righthaswall==0) break;
				settrack(0);
				while(1)
					if(track>=36) break;
			}
			if(actionsequence[i]==LT90SEARCH)
			{
				task=SMARTSTRAIGHT;
				while(1)
					if(lefthaswallh==1&&lefthaswall==0) break;
				settrack(0);
				while(1)
					if(track>=36) break;
			}
 
		}
		while(actionsequence[i]!=0)
		{
			if(actionsequence[i]==STRAIGHT_spurt_90)
			{
				num=0;
				while(actionsequence[i]==STRAIGHT_spurt_90)
				{
					num++;
					i++;
				}
				if( GoOrBackFlag==1 && back90_flag==1 && actionsequence[0]==STRAIGHT_spurt_90 )
				{
					if(GucMouseTask==SPURT_45)
					{
						if(num==1)
						{
							taskstraight90(80*num+80);
							settrack(0);
						}
						else taskstraight90(180*num-100+80);
					}
					else if(GucMouseTask==SPURT_90)
						{
							if(num==1)
							{
								taskstraight90(80*num+80);
								settrack(0);
							}
							else taskstraight90(180*num-100+80);
						}
						back90_flag=0;
				}
				else if(num==1)
					{
						taskstraight90(80*num);
						settrack(0);
					}
					else taskstraight90(180*num-100);	 
 
				if(actionsequence[i]==RT90SEARCH)
				{
					task=SMARTSTRAIGHT;
					while(1)
						if(righthaswallh==1&&righthaswall==0) break;
					settrack(0);
					while(1)
						if(track>=36) break;
				}
				if(actionsequence[i]==LT90SEARCH)
				{
					task=SMARTSTRAIGHT;
					while(1)
						if(lefthaswallh==1&&lefthaswall==0) break;
					settrack(0);
					while(1)
						if(track>=36) break;
				}
 
			}
			else
			{
 
				spurt_45_end_flag=0; 
				if(actionsequence[i]==RT90SEARCH) mouseTurnright_spurt();
				if(actionsequence[i]==LT90SEARCH) mouseTurnleft_spurt();
				i++;
			}
		}
		if(GoOrBackFlag==1) decdistance=30;
		else 			if(BackSearchFlag==0)
				decdistance=30;
			else if(BackSearchFlag==1)
				decdistance=30+150; 
			else decdistance=30;
		taskstop();
 
 
 
		if(BackSearchFlag==1)
		{tick=0;
		turnaround_tick=0;
		task=KEEPWALLDISTANCE;
		while(tick<50);
		}
 

	}
	
}

int getfinaldir_90()
{
	int ret=0,i=0;
	for(i=0;i<FastwayCount_90;i++)
	{
		if(FastwayAction_90[i].action==3) ret+=-1;
		else ret+=FastwayAction_90[i].action;
	}
	return ret%4;
}

 
void mouseTurnright_spurt()
{
	goaheadbugflag=0;
	before90turn_r_spurt();
	if(lefthaswall==1)
	{
		turnrighto=dis2wall-((disl+dislh+dislhh)/3);
		turno=(disr+disrh+disrhh)/3-dis2wall;
	}
	else
	{
		turnrighto=0;
		turno=0;
	}
	taskturn(RT90SPURT);   
	task=SMARTSTRAIGHT;
	GucMouseDir=(GucMouseDir + 1) % 4; 
	settrack(180-turnrighto);
	task=SMARTSTRAIGHT;
	while(track<=180);
	settrack(0);
}

void mouseTurnleft_spurt()
{
	goaheadbugflag=0;
	before90turn_l_spurt();
	if(righthaswall==1)
	{
		turnlefto=(disr+disrh+disrhh)/3-dis2wall;
		turno=(disr+disrh+disrhh)/3-dis2wall;
	}
	else
	{
		turnlefto=0;
		turno=0;
	}
	taskturn(LT90SPURT);   
	task=SMARTSTRAIGHT;
	GucMouseDir=(GucMouseDir + 3) % 4;
	settrack(180+turnlefto);
	task=SMARTSTRAIGHT;
	while(track<=180);
	settrack(0);
}

void before90turn_l_spurt()		 
{
	 

											 
	 
	 
	{
		e=0;eh=0;
 
 
 
 
 
		settrack(0);
 
 
		task=BEFORE90TURN; 
		while(1)
		{
 
			if(track>=20) {turno=0;break;}
			 
		}
	}

}	
void before90turn_r_spurt()		 
{
	 
	 
	 
	 
	{
		e=0;eh=0;
 
 
 
 
 
		settrack(0);
 
 
		task=BEFORE90TURN; 
		while(1)
		{
		if(track>=20) {turno=0;break;} 
			}
	}

}	


void spurt_back_mouseTurnback()
{				
	goaheadbugflag=0;
	settrack(0);
	
	task=SMARTSTRAIGHT;			   
	tick=0;
	turnaround_tick=0;
	task=BEFORE180TURN;
	while(tick<50);
	settrack(0);

	taskturnaround();
	GucMouseDir = (GucMouseDir + 2) % 4;
	settrack(0);
}






